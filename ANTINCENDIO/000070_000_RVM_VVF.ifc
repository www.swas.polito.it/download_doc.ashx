Properties of the parts of a building model (IFC2X3), part 32 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6406498 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6406504 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0445 | Protezione antincendio a secco 35
6406506 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6406538 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406546 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6406552 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0445 | Protezione antincendio a secco 35
6406554 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6406584 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406592 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6406598 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0445 | Protezione antincendio a secco 35
6406600 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6406797 | Piano 1 (+4.80) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406815 | Piano 1 (+4.80) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406828 | Piano 1 (+4.80) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6407712 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 35
6407719 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 35
6407730 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6407734 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6407739 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 35
6407744 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 35
6407757 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6407759 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6408384 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 90 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.02342 | Protezione antincendio a secco 90 | Dati identità - Commenti: Rampa 0-1
6408390 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.06632 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408394 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 108 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.87342 | Protezione antincendio a secco 108 | Dati identità - Commenti: Rampa 0-1
6408400 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.91632 | Protezione antincendio a secco 114
6408412 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.67342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408418 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 120 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.71632 | Protezione antincendio a secco 120 | Dati identità - Commenti: Rampa 0-1
6408426 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.08342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408432 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.18632 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408436 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.66904 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408442 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.79194 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408452 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.31342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408458 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.31632 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408466 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 156 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.86609 | Protezione antincendio a secco 156 | Dati identità - Commenti: Rampa 0-1
6408472 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 161 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.74899 | Protezione antincendio a secco 161 | Dati identità - Commenti: Rampa 0-1
6408482 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 176 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.29342 | Protezione antincendio a secco 176 | Dati identità - Commenti: Rampa 0-1
6408488 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.33632 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408500 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 90 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.91304 | Protezione antincendio a secco 90 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6408504 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.90956 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408518 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.25979 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6408520 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.26449 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408536 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72378 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408538 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72434 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408548 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37306 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408552 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37298 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408565 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95088 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408567 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95089 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408589 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14692 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408591 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14694 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408597 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.55158 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408599 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.55162 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408603 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 108 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 108 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6408605 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114 | Dati identità - Commenti: Rampa 0-1
6408656 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 114
6408663 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 114
6408674 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408678 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408683 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 114
6408688 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.85342 | Protezione antincendio a secco 114
6408701 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408703 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408992 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6408999 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6409009 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409013 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409018 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6409025 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6409036 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409040 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409045 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 151 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 151
6409050 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 166 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 166
6409061 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 166 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 166 | Meccanico - Flusso - Caduta pressione: 0 Pa
6409063 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 151 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 151 | Meccanico - Flusso - Caduta pressione: 0 Pa
6409070 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6409075 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6409087 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409089 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409097 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6409104 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6409114 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409118 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6411259 | Piano 3 (+12.85) | 0.1 | 0.0686 | 0.0544 | 0.06393 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1372 | 0.1088 | 0.12786 | 0.10064 | 0.1144 | 0.0889 | 0.1 | 0.08 | 0.051144 | 0.040256 | 0.08 | ø100xø80 | 0.0168 | 0.0139 | 0.1113 | 0.05 | 0.04 | 0.00673 | 0.00587 | 0.00120775 | ø100 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6411261 | Piano 3 (+12.85) | 0.1 | 0.0686 | 0.0544 | 0.06393 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1372 | 0.1088 | 0.12786 | 0.10064 | 0.1144 | 0.0889 | 0.1 | 0.08 | 0.051144 | 0.040256 | 0.08 | ø100xø80 | 0.0168 | 0.0139 | 0.1113 | 0.05 | 0.04 | 0.00673 | 0.00587 | 0.00120775 | ø100 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6418785 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | VE5408 | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6419005 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | VE5417 | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6419128 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | VE5425 | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419196 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | VE5436 | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Type - Altro - Categoria: Tubazione; Nome famiglia: Tubazione
Type - Dati identità - Costo: 0; Descrizione: Acciaio filettato morbido; Nome del tipo: Acciaio - per impianto sprinkler
Pset_DistributionFlowElementCommon - Reference: Acciaio - per impianto sprinkler
Altro - Famiglia: Tubazione: Acciaio - per impianto sprinkler; Famiglia e tipo: Tubazione: Acciaio - per impianto sprinkler; ID tipo: Tubazione: Acciaio - per impianto sprinkler; Tipo: Tubazione: Acciaio - per impianto sprinkler
Fasi - Fase di creazione: Stato di Progetto
Isolamento - Spessore isolamento: 0 m
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco; Classificazione sistema: Protezione antincendio a secco; Tipo di connessione: Generico
Vincoli - Giustificazione orizzontale: Al centro; Giustificazione verticale: Al centro
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6267266 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.60293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282973 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6267512 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.62286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.284539 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6270573 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6270626 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6270671 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.6 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.361911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6270683 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
