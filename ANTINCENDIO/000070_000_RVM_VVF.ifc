Properties of the parts of a building model (IFC2X3), part 4 of 58

# IfcFlowFitting: Standard (385)
Name (M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150:Standard:...) | In | Da centro a estremità 1 (m) | Da centro a estremità 2 (m) | Da centro a estremità maschio 1 (m) | Da centro a estremità maschio 2 (m) | Lunghezza 1 (m) = Lunghezza 5 (m) | Lunghezza 2 (m) | Lunghezza 3 (m) | Lunghezza 4 (m) | Raggio centro (m) | Raggio esterno banda (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Contrassegno | Angolo (deg) | Da centro a estremità (m) | Da centro a estremità maschio (m) | Diametro esterno banda (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Diametro porta estremità maschio (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Lunghezza filettatura esterna (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6280472 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280516 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280586 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280630 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280698 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280742 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280850 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280894 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280962 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281006 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281072 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281116 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281184 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281228 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281294 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281338 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281404 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281448 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281514 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281558 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281624 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281668 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281758 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281802 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281924 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281938 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282016 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282030 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282585 | Piano 2 (+8.61) | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Secondo | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282742 | Piano 2 (+8.61) | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Secondo | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187463 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6283366 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6283500 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6283781 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | Piano Secondo | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6287225 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6287227 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288357 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288435 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288922 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6289257 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6289308 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6289365 | Piano 2 (+8.61) | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Secondo | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292021 | Piano 2 (+8.61) | 0.0285 | 0.0224 | 0.0412 | 0.0292 | 0.0222 | 0.00544 | 0.0222 | 0.0222 | 0.0222 | 0.0152 | 0.01332 | 0.00917 | Piano Secondo | 90 | 0.0285 | 0.0412 | 0.0304 | 0.02664 | 0.01834 | 0.0213 | 0.015 | 0.013 | 0.010656 | ø15xø15 | 0.0063 | 0.01356 | 0.0075 | 0.00267 | 0.0000189054 | ø15 mmxø15 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292112 | Piano 2 (+8.61) | 0.0285 | 0.0224 | 0.0412 | 0.0292 | 0.0222 | 0.00544 | 0.0222 | 0.0222 | 0.0222 | 0.0152 | 0.01332 | 0.00917 | Piano Secondo | 90 | 0.0285 | 0.0412 | 0.0304 | 0.02664 | 0.01834 | 0.0213 | 0.015 | 0.013 | 0.010656 | ø15xø15 | 0.0063 | 0.01356 | 0.0075 | 0.00267 | 0.0000189054 | ø15 mmxø15 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6294666 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294710 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294758 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294772 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294814 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294828 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294866 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294901 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294945 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294961 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295003 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295032 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 69 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 69
6295076 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 69 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 69
6295101 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295145 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295170 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295214 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295239 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295283 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295308 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295352 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295377 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295421 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295446 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295490 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295511 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295555 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295574 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295618 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295637 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295681 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295700 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295744 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295763 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295807 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295821 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295866 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295917 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295961 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6295980 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296024 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296043 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296087 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296106 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296150 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296169 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296213 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296232 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296276 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296301 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296345 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296370 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296414 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296439 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296483 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296508 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296552 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296577 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296621 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296646 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296690 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296736 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296750 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296792 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296806 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296854 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296858 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6296862 | Piano 1 (+4.80) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | Piano Primo | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297016 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297018 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297031 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297070 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297122 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297154 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297182 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6297281 | Piano 1 (+4.80) | 0.0285 | 0.0224 | 0.0412 | 0.0292 | 0.0222 | 0.00544 | 0.0222 | 0.0222 | 0.0222 | 0.0152 | 0.01332 | 0.00917 | Piano Primo | 90 | 0.0285 | 0.0412 | 0.0304 | 0.02664 | 0.01834 | 0.0213 | 0.015 | 0.013 | 0.010656 | ø15xø15 | 0.0063 | 0.01356 | 0.0075 | 0.00267 | 0.0000189054 | ø15 mmxø15 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6299128 | Piano 1 (+4.80) | 0.0285 | 0.0224 | 0.0412 | 0.0292 | 0.0222 | 0.00544 | 0.0222 | 0.0222 | 0.0222 | 0.0152 | 0.01332 | 0.00917 | Piano Primo | 90 | 0.0285 | 0.0412 | 0.0304 | 0.02664 | 0.01834 | 0.0213 | 0.015 | 0.013 | 0.010656 | ø15xø15 | 0.0063 | 0.01356 | 0.0075 | 0.00267 | 0.0000189054 | ø15 mmxø15 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6300296 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6300556 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6302075 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6302591 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6302703 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6305942 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
