Properties of the parts of a building model (IFC2X3), part 57 of 58

# IfcFlowTerminal: VVF_tipo_VK520_upright (752)
Name (VVF_tipo_VK520_upright:VVF_tipo_VK520_upright:...) | In | Contrassegno | Nome sistema | Tipo di sistema | Tipologia impianto | Host | Livello | Offset (m) | Group
6319203 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 55 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 55
6319204 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 56 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 56
6319258 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 72 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 72
6319320 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 60 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 60
6319321 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 61 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 61
6319375 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 78 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 78
6319439 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 64 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 64
6319440 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 66 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 66
6319494 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 85 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 85
6319556 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 71 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 71
6319557 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 73 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 73
6319611 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 91 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 91
6319677 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6319678 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 79 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 79
6319732 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 97 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 97
6319821 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6319822 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 86 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 86
6319876 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 103 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 103
6320319 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6320320 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 92 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 92
6320374 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 109 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 109
6320436 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6320437 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 98 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 98
6320491 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 115 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 115
6320555 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6320556 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 104 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 104
6320610 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 121 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 121
6320672 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6320673 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 110 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 110
6320727 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 127 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 127
6320791 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6320792 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 116 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 116
6320846 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 134 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 134
6320906 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6320907 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 122 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 122
6320961 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 141 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 141
6321025 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6321026 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 128 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 128
6321080 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 147 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 147
6321406 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6321407 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 95 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 95
6321459 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 139 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 139
6321535 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6321536 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 107 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 107
6321588 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 146 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 146
6321685 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6321686 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 125 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 125
6321738 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 153 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 153
6321802 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6321803 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 135 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 135
6321855 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 158 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 158
6321919 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6321920 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 145 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 145
6321972 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 163 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 163
6322050 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322051 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 152 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 152
6322103 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 168 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 168
6322213 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322214 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 157 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 157
6322266 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 173 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 173
6322328 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322329 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 162 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 162
6322381 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 178 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 178
6322443 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322444 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 167 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 167
6322496 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 183 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 183
6322558 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322559 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 172 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 172
6322611 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 188 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 188
6322673 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322674 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 177 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 177
6322726 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 193 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 193
6322788 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322789 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 182 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 182
6322841 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 198 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 198
6322903 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6322904 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 187 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 187
6322956 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 203 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 203
6323018 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6323019 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 192 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 192
6323071 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 208 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 208
6323133 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6323134 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 197 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 197
6323186 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 213 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 213
6323248 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6323249 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 202 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 202
6323301 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 218 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 218
6323373 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 206 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 206
6323374 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 207 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 207
6323428 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 224 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 224
6323506 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6323629 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6323685 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 217 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 217
6323686 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 219 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 219
6323689 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6323822 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 223 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 223
6323823 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 227 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 227
6323826 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6323937 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 230 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 230
6323938 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 233 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 233
6323941 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6324052 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 236 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 236
6324053 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 239 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 239
6324056 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6324167 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 242 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 242
6324168 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 245 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 245
6324171 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6324282 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 248 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 248
6324283 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 251 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 251
6324286 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6324397 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 254 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 254
6324398 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 257 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 257
6324401 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6324512 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 260 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 260
6324513 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 263 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 263
6324516 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6324627 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 266 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 266
6324628 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 269 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 269
6324631 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6324742 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 272 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 272
6324743 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 275 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 275
6324746 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6325553 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6325637 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6325678 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 281 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 281
6325679 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 282 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 282
6325947 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 53 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 53
6325948 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 286 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 286
6326072 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 290 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 290
6326073 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 291 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 291
6326076 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6326706 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6326764 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6326797 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6326857 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 298 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 298
6326858 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 299 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 299
6326949 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 302 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 302
6326950 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 303 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 303
6327036 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 306 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 306
6327037 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 308 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 308
6327110 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 311 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 311
6327111 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 313 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 313
6327186 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 316 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 316
6327187 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 318 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 318
6327260 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 321 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 321
6327261 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 323 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 323
6327359 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 326 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 326
6327360 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 328 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 328
6327536 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 331 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 331
6327537 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 333 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 333
6327540 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6327735 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 338 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 338
6327736 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 340 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 340
6330293 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 20 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 20
6330294 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 26 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 26
6333234 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 8 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 8
6333235 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 14 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 14
6333238 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6333415 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 43 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 43
6333416 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 59 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 59
6333487 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 70 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 70
6333488 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 76 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 76
6333571 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6333624 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6377073 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 96 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.15 | Protezione antincendio a secco 96 | Dati identità - Commenti: Rampa 0-1
6377074 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.15 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377083 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377084 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6377131 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.8 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377132 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 96 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.8 | Protezione antincendio a secco 96 | Dati identità - Commenti: Rampa 0-1
6377161 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.21 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377162 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.27 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377191 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.79562 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377192 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.87562 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377217 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.44 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377218 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.4 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377243 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 196 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.99267 | Protezione antincendio a secco 196 | Dati identità - Commenti: Rampa 0-1
6377244 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 201 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.83267 | Protezione antincendio a secco 201 | Dati identità - Commenti: Rampa 0-1
6377271 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 234 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.42 | Protezione antincendio a secco 234 | Dati identità - Commenti: Rampa 0-1
6377272 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.42 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6388069 | PR_VVF_0200_SPR_Sezione su scala | 1487 | Protezione antincendio a secco 264 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.82 | Protezione antincendio a secco 264 | Dati identità - Commenti: rampa 0-1
6388070 | PR_VVF_0200_SPR_Sezione su scala | 1488 | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.82 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388085 | PR_VVF_0200_SPR_Sezione su scala | 1489 | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.92 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388086 | PR_VVF_0200_SPR_Sezione su scala | 1490 | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.92 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6402795 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6402953 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6403146 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6403151 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6403657 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6403662 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6404176 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6404181 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6404453 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6404458 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6404788 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404793 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404814 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404819 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404841 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404846 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404868 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404873 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404895 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6404900 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6405236 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6405241 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6405262 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6405267 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6405289 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 40 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 40
6405294 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 40 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 40
6405316 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6405321 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6405343 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6405348 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6406488 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6406489 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6406536 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6406537 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6406582 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6406583 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6407709 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 35
6407714 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 35
6407736 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 35
6407741 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 35
6408382 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 90 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.15 | Protezione antincendio a secco 90 | Dati identità - Commenti: Rampa 0-1
6408383 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.15 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408392 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 108 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 108 | Dati identità - Commenti: Rampa 0-1
6408393 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 114 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 114
