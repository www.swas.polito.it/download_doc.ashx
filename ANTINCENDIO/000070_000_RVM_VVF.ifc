Properties of the parts of a building model (IFC2X3), part 53 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6405349 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3173 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6405351 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.841613 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0661001 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3173 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405355 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.998719 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0784392 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3170 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405359 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.31887 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.582796 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3161 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405744 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.731228 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.183778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 494 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405856 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.98654 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.00193 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 835 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406387 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.8095 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282442 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 851 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406486 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3135 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406492 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3138 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6406494 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3135 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6406496 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3134 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406501 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3133 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406534 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3153 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406540 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3156 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6406542 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3153 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6406544 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3152 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406549 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3151 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406580 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3144 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406586 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3147 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6406588 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3144 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6406590 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3143 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406595 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3142 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406767 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 0.616514 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.193684 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3129 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406790 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.2842 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.717602 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3131 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406808 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 0.546105 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.171564 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3140 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6406821 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.16073 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.678815 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 816 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6407207 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.2649 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0665766 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2862 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.8 | 7.8 | Protezione antincendio a secco 35
6407324 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 1.96525 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.493921 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.39512 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2862 | 0.001 | impianto a secco | 0.184859 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.79169 | 7.43445 | Protezione antincendio a secco 35
6407703 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.0448728 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3239 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6407705 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.99112 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.00308 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3239 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6407710 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3250 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6407715 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3247 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6407717 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.701333 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0550826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3247 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6407721 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.13862 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0894267 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3250 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6407726 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.44642 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.866181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3238 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6407737 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3244 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6407742 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3241 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6407746 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.86106 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0676275 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3241 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6407754 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.981976 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0771242 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3244 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6408024 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.372777 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0936891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3238 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6408372 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 1.31923 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.331558 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.52237 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3265 | 0.001 | impianto a secco | 0.134322 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.56202 | 6.73764 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408374 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.10256 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.779759 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.69618 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3262 | 0.001 | impianto a secco | 0.154557 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.73571 | 5.20961 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408376 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.77122 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.445156 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.86364 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3260 | 0.001 | impianto a secco | 0.0918575 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.90347 | 4.06549 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408380 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.600673 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0471767 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 90 | 3.89876 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.91126 | 3.91127 | Protezione antincendio a secco 90 | Dati identità - Commenti: Rampa 0-1
6408386 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0740649 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00581704 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 90 | 3.94936 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.02342 | 3.94936 | Protezione antincendio a secco 90 | Dati identità - Commenti: Stacco
6408388 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0888308 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00697675 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.93459 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3300 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.02342 | 3.93459 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408396 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.14922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0117197 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 108 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7242 | Protezione antincendio a secco 108 | Dati identità - Commenti: Stacco
6408398 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.14922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0117197 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2911 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7242 | Protezione antincendio a secco 114 | Dati identità - Commenti: Stacco
6408406 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.759831 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.059677 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 108 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 108 | Dati identità - Commenti: Rampa 0-1
6408408 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.17981 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0926617 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.88384 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3300 | 0.0032 | impianto a secco | 0.000120747 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.89649 | 3.89634 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408414 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.375506 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0294921 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.29792 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3297 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.67342 | 4.29792 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408416 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.402997 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0316513 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 120 | 4.27042 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.67342 | 4.27042 | Protezione antincendio a secco 120 | Dati identità - Commenti: Stacco
6408428 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.321572 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0252562 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.76185 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3289 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.08342 | 4.76185 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408430 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.381545 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0299665 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.76188 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3292 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.14342 | 4.76188 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408438 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.257957 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0202599 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.41108 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3283 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.66904 | 5.41108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408440 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.338126 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0265563 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.41091 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3286 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.74904 | 5.41091 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408444 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.858419 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.06742 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.36032 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3286 | 0.0032 | impianto a secco | 0.000365212 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.37314 | 5.37282 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408448 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.733387 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0576001 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.93835 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3277 | 0.0032 | impianto a secco | 0.000179718 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.95085 | 5.95099 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408454 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.32433 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0254728 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.98909 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3277 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.31342 | 5.98909 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408456 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.284306 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0223293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.98912 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3280 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.27342 | 5.98912 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408460 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.888904 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0698144 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.93839 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3280 | 0.0032 | impianto a secco | 0.000134659 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.95089 | 5.95101 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408462 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 0.409198 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.102843 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.92261 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3264 | 0.001 | impianto a secco | 0.145961 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.96219 | 6.02129 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408468 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.302721 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0237756 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 156 | 6.56337 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.86609 | 6.56337 | Protezione antincendio a secco 156 | Dati identità - Commenti: Stacco
6408470 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.142773 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112133 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 161 | 6.56331 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.70609 | 6.56331 | Protezione antincendio a secco 161 | Dati identità - Commenti: Stacco
6408478 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 2.05158 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.515619 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.11723 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3266 | 0.001 | impianto a secco | 0.128608 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.15691 | 7.4186 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408484 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 176 | 7.1581 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.29342 | 7.1581 | Protezione antincendio a secco 176 | Dati identità - Commenti: Stacco
6408486 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.108397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00851351 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.18502 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3268 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.29342 | 7.18502 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408496 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.16485 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.544085 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.65131 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3259 | 0.001 | impianto a secco | 0.0918575 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.69114 | 3.88917 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408510 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.08966 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.525188 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.03453 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3260 | 0.001 | impianto a secco | 0.0858484 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.07438 | 4.25312 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408512 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.61899 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.658225 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.22665 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3261 | 0.001 | impianto a secco | 0.0858484 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.2665 | 4.49051 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408514 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.39742 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.109753 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 120 | 4.21922 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco | 0.000429156 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.23232 | 4.23172 | Protezione antincendio a secco 120 | Dati identità - Commenti: Rampa 0-1
6408516 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.467088 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.036685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.24732 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3297 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.25982 | 4.25982 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408526 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.36844 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343927 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.46327 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3261 | 0.001 | impianto a secco | 0.154557 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.5028 | 4.71183 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408532 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.733718 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0576261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.71125 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3289 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.72375 | 4.72375 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408534 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 1.14412 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0898592 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.71128 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3292 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.72378 | 4.72378 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408544 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 0.885906 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.222652 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.19417 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3262 | 0.001 | impianto a secco | 0.145961 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.23375 | 5.36171 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408546 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.954321 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0749522 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.36048 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3283 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.37298 | 5.37298 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408563 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 3.84481 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.966305 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.34471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3263 | 0.001 | impianto a secco | 0.145961 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.38429 | 5.9396 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408579 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 3.80065 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.955207 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.99558 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3264 | 0.001 | impianto a secco | 0.134322 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.03523 | 6.5412 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408583 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 2.96446 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.74505 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.71914 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3265 | 0.001 | impianto a secco | 0.128608 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.75882 | 7.13696 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408585 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.712792 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0559826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.13442 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3268 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.14692 | 7.14692 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408587 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.87984 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0691025 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.13444 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3271 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.14696 | 7.14694 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408593 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.889057 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0698263 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.53912 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3275 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.55162 | 6.55162 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408595 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 1.18902 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0933858 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.53906 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3273 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.55156 | 6.55158 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408601 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.06889 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0839501 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2911 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408649 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.0448728 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3239 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408651 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.99112 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.00308 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3239 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408654 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3250 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 114 | Dati identità - Commenti: Stacco
6408659 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3247 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 114 | Dati identità - Commenti: Stacco
6408661 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.701333 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0550826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3247 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408665 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.13862 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0894267 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3250 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408670 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.44642 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.866181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3238 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408681 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3244 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 114 | Dati identità - Commenti: Stacco
6408686 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.12922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0101489 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3241 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7242 | 3.85342 | Protezione antincendio a secco 114 | Dati identità - Commenti: Stacco
6408690 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.86106 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0676275 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3241 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408698 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.981976 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0771242 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3244 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408715 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.372777 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0936891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 114 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3238 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 114
6408920 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.0318 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.25932 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3259 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408926 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.604374 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.151896 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3303 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408969 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.321572 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0252562 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 89 | 4.76185 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2894 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.08342 | 4.76185 | Dati identità - Commenti: Stacco
6408971 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.381545 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0299665 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 102 | 4.76188 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2897 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.14342 | 4.76188 | Dati identità - Commenti: Stacco
6408973 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 119 | 7.1581 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.29342 | 7.1581 | Dati identità - Commenti: Stacco
6408975 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.108397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00851351 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 126 | 7.18502 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2877 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.29342 | 7.18502 | Dati identità - Commenti: Stacco
6408979 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.083909 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0210886 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3305 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6408981 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.87907 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.974916 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3305 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6408983 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.0448728 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3320 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6408987 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.89541 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.979024 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3320 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6408990 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3330 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408995 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3333 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6408997 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.729583 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0573013 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3333 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409001 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.10785 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0870107 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3330 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409005 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.0693874 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.017439 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3319 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409016 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3327 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6409021 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3324 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
