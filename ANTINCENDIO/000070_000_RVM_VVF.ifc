Properties of the parts of a building model (IFC2X3), part 13 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6281086 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281094 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281102 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281106 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281112 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281114 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281120 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281122 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281175 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281178 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281180 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281186 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281196 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281198 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281206 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281214 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281218 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281224 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281226 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281285 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281288 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281290 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281296 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281306 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281308 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281316 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281324 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281328 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281334 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281336 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281342 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281344 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281395 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281398 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281400 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281406 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281416 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281418 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281426 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281434 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281438 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281444 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281446 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281452 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281454 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281505 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281508 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281510 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281516 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281526 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281528 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281536 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281544 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281548 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281554 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281556 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281562 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281564 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281615 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281618 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281620 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281626 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281636 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281638 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281646 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281654 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281658 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281664 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281666 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281672 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281674 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281749 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281752 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281754 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281760 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281770 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281772 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281780 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281788 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281792 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281798 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281800 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281891 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281894 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281898 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281910 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6281914 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281920 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281922 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281928 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281930 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281932 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281940 | Piano 2 (+8.61) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281983 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281986 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281990 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6282002 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6282006 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6282012 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6282014 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6282020 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282022 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
