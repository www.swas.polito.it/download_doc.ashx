Properties of the parts of a building model (IFC2X3), part 8 of 58

# IfcFlowFitting: Standard (475)
Name (M_Raccordo a T - Filettato - MI - Classe 150:Standard:...) | In | Angolo 1 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6295845 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295874 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295890 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295925 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295943 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295953 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295988 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296006 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296016 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296051 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296069 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296079 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296114 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296132 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296142 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296177 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296195 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296205 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296240 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296258 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296268 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296309 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296327 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296337 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296378 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296396 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296406 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296447 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296465 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296475 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296516 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296534 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296544 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296585 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296603 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296613 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296654 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296672 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296682 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296720 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296728 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296776 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296784 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296870 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297039 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297053 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297078 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297092 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297098 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297106 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297130 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297138 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297162 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297168 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297190 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297196 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6300266 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6300564 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6300582 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6302067 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6302599 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6302613 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6302711 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6305932 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306063 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306077 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306153 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306209 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306223 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306276 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306290 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306343 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306357 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306410 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306424 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306479 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306493 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306546 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306560 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306613 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306627 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306682 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306696 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306749 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306763 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306816 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306830 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306881 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306895 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306948 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6306962 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307015 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307029 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307556 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307601 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307706 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307720 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307773 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307787 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307840 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307854 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307907 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307921 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307974 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6307988 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308041 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308055 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308108 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308122 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308175 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308189 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308242 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308256 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308309 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308323 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308376 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308390 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308530 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308579 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308698 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308745 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308806 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308820 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308873 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308887 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6308958 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309005 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 80 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.7
6309100 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309114 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Terra | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309351 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Terra | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309466 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309544 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309595 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309651 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309691 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309742 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309782 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309822 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309862 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309902 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6309942 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
