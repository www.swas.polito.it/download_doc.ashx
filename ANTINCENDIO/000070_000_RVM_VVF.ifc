Properties of the parts of a building model (IFC2X3), part 43 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6308039 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1755 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308042 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1756 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308049 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1763 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308053 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1753 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308056 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1754 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308092 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1744 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308098 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1744 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308104 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1747 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308106 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1742 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308109 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1743 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308116 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1750 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308120 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1740 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308123 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1741 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308159 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1731 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308165 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1731 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308171 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1734 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308173 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1729 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308176 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1730 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308183 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1737 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308187 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1727 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308190 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1728 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308226 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1718 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308232 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1718 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308238 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1721 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308240 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1716 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308243 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1717 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308250 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1724 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308254 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1714 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308257 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1715 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308293 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1705 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308299 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1705 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308305 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1708 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308307 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1703 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308310 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1704 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308317 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1711 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308321 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1701 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308324 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1702 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308360 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1692 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308366 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1692 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308372 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1695 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308374 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1690 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308377 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1691 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308384 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1698 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308388 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1688 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308391 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1689 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308516 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.267265 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1662 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308522 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1665 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308524 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1662 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308526 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1661 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308531 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 2.57401 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.258768 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1660 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308565 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.267265 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1641 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308571 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1644 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308573 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1641 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308575 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1640 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308580 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 2.57401 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.258768 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1639 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308684 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.267265 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1625 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308690 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1628 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308692 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1625 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308694 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1624 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308699 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 2.57401 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.258768 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1623 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308731 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.267265 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1617 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308737 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1620 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308739 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1617 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308741 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1616 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308746 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 2.57401 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.258768 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1615 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308790 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1672 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308796 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1672 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308802 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1675 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308804 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1670 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308807 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1671 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308814 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1678 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308818 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1668 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308821 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1669 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308857 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1651 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308863 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1651 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308869 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1654 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308871 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1649 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308874 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1650 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308881 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1657 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308885 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1647 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308888 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1648 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308942 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1633 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308948 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1633 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308954 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1636 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308956 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.514716 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0517449 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1631 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308959 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1632 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308989 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 80 | 3.6875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 428 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7 | 3.7 | Protezione antincendio a secco 80
6308995 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.236362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0185638 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 80 | 3.73706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 428 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.73706 | Protezione antincendio a secco 80 | Dati identità - Commenti: Stacco
6309001 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.176622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0138718 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 80 | 3.7968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 431 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7968 | Protezione antincendio a secco 80 | Dati identità - Commenti: Stacco
6309003 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.71112 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0714896 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 80 | 3.684 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 426 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7 | 3.7 | Protezione antincendio a secco 80
6309006 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 80 | 3.684 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 427 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7 | 3.7 | Protezione antincendio a secco 80
6309084 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.60286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282968 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1598 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309090 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1598 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6309096 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1601 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6309098 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.61 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.362917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1596 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309101 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1597 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309108 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1604 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6309112 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.506152 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636049 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1594 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309115 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1595 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309337 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.60293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282973 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1609 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309343 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1612 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6309345 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1609 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6309347 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1608 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309352 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 2.81401 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282895 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1607 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309467 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.42897 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.861794 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1591 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309545 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.8736 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.722215 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1590 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309596 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.355172 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0892645 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1589 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309652 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.37753 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.597539 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1588 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309692 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.67693 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.170131 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1587 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309743 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.04027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.512776 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1586 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309783 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.00765 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.253249 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1585 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309823 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.7161 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.431303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1584 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
