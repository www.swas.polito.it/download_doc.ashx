Properties of the parts of a building model (IFC2X3), part 5 of 58

# IfcFlowFitting: Standard (385)
Name (M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150:Standard:...) | In | Da centro a estremità 1 (m) | Da centro a estremità 2 (m) | Da centro a estremità maschio 1 (m) | Da centro a estremità maschio 2 (m) | Lunghezza 1 (m) = Lunghezza 5 (m) | Lunghezza 2 (m) | Lunghezza 3 (m) | Lunghezza 4 (m) | Raggio centro (m) | Raggio esterno banda (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Contrassegno | Angolo (deg) | Da centro a estremità (m) | Da centro a estremità maschio (m) | Diametro esterno banda (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Diametro porta estremità maschio (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Lunghezza filettatura esterna (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6306055 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306201 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306268 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306335 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306402 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306471 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306538 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306605 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306674 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306741 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306808 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306873 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6306940 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307007 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307548 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307593 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307698 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307765 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307832 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307899 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6307966 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308033 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308100 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308167 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308234 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308301 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308368 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308538 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308587 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308706 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308753 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308798 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308865 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308950 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6308997 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 80 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.7 | Protezione antincendio a secco 80
6309092 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309359 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6313077 | PR_VVF_0200_SPR_Sezione su scala | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Terra | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.7 | Protezione antincendio a secco 35
6325533 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0241 | 0.00136 | 0.0475823 | 0.00542132 | 0.211523 | 0.02735 | 0.02478 | 0.01878 | Piano Uffici | 13 | 0.0328 | 0.0434 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.0000933887 | ø32 mmxø32 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6325535 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0241 | 0.00136 | 0.0475823 | 0.00542132 | 0.211523 | 0.02735 | 0.02478 | 0.01878 | Piano Uffici | 13 | 0.0328 | 0.0434 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.0000933887 | ø32 mmxø32 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6326436 | Piano 3 (+12.85) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0208 | 0.00079375 | 0.0413319 | 0.00332876 | 0.258265 | 0.0225 | 0.0201 | 0.01495 | Piano Uffici | 9.20902 | 0.0285 | 0.0373 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000528786 | ø25 mmxø25 mm | Protezione antincendio a secco 291 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 291
6326681 | Piano 3 (+12.85) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0208 | 0.00079375 | 0.0413083 | 0.00347102 | 0.247539 | 0.0225 | 0.0201 | 0.01495 | Piano Uffici | 9.60622 | 0.0285 | 0.0373 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000528709 | ø25 mmxø25 mm | Protezione antincendio a secco 291 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 291
6329232 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | Piano Uffici | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6331256 | Piano 3 (+12.85) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Uffici | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6333853 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0241 | 0.00136 | 0.0478662 | 0.00399724 | 0.288593 | 0.02735 | 0.02478 | 0.01878 | Piano Uffici | 9.54724 | 0.0328 | 0.0434 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.0000936461 | ø32 mmxø32 mm | Protezione antincendio a secco 83 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 83
6333855 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0241 | 0.00136 | 0.0478662 | 0.00399724 | 0.288593 | 0.02735 | 0.02478 | 0.01878 | Piano Uffici | 9.54724 | 0.0328 | 0.0434 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.0000936461 | ø32 mmxø32 mm | Protezione antincendio a secco 83 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 83 | Meccanico - Flusso - Caduta pressione: 0 Pa
6333911 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0241 | 0.00136 | 0.0462842 | 0.00941662 | 0.118455 | 0.02735 | 0.02478 | 0.01878 | Piano Uffici | 23 | 0.0328 | 0.0434 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.0000926585 | ø32 mmxø32 mm | Protezione antincendio a secco 101 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 101
6333928 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0241 | 0.00136 | 0.0462842 | 0.00941662 | 0.118455 | 0.02735 | 0.02478 | 0.01878 | Piano Uffici | 23 | 0.0328 | 0.0434 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.0000926585 | ø32 mmxø32 mm | Protezione antincendio a secco 101 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 101
6377093 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6377095 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377147 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 96 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.23232 | Protezione antincendio a secco 96 | Dati identità - Commenti: Rampa 0-1
6377151 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.25982 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377207 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37298 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377253 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 196 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.52527 | Protezione antincendio a secco 196 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6377255 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 201 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.52521 | Protezione antincendio a secco 201 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6377281 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 234 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.12 | Protezione antincendio a secco 234 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6377295 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14692 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6378433 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0303995 | 0.0304 | 0.0303995 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90.0009 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626241 | ø25 mmxø25 mm | Protezione antincendio a secco 96 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.91126 | Protezione antincendio a secco 96 | Dati identità - Commenti: Rampa 0-1
6378590 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304037 | 0.0304 | 0.0304037 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 89.9931 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626264 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.89649 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6379495 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0741609 | 0.0247188 | 0.123608 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 36.8678 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000670631 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.06967 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6380791 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0703907 | 0.0290748 | 0.0997462 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 44.886 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000660268 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.49439 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381143 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72375 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381164 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72378 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381822 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0643 | 0.01982 | 0.109131 | 0.0460946 | 0.152232 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 45.7965 | 0.0782 | 0.1146 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.00102813 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.22246 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6382789 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0303889 | 0.0304 | 0.0303889 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90.0209 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626218 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37281 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6383314 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304018 | 0.0304 | 0.0304018 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 89.9966 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626254 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95102 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6383360 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304055 | 0.0304 | 0.0304055 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 89.9897 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626274 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95099 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6383704 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0753442 | 0.0230567 | 0.134633 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 34.0301 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000674085 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.02789 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6384244 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0643 | 0.01982 | 0.105141 | 0.0496641 | 0.136126 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 50.5681 | 0.0782 | 0.1146 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.00101698 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.74884 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387899 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0751736 | 0.0233073 | 0.132883 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 34.4518 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000673593 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6388079 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE4557 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 264 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.40868 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: rampa 0-1
6388081 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE4560 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43292 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: rampa 0-1
6388095 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE4564 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43319 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: rampa 0-1
6388097 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE4582 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43319 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: rampa 0-1
6388190 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0782603 | 0.0179993 | 0.179136 | 0.0544 | 0.05032 | 0.04117 | VE4611 | 25.9048 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000682547 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43317 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6402707 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0785399 | 0.0174119 | 0.185841 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 25 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000683332 | ø80 mmxø80 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6402759 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0811762 | 0.00996718 | 0.335547 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 14 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000690822 | ø80 mmxø80 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403105 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403128 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403601 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403631 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404101 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404105 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404157 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0732184 | 0.025928 | 0.116345 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 39 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.0006679 | ø80 mmxø80 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404189 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404359 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404376 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0775774 | 0.0193422 | 0.165244 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 28 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000680483 | ø80 mmxø80 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404567 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404626 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404784 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0811762 | 0.00996718 | 0.335547 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 14 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000690822 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404806 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404810 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404833 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404837 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404854 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404856 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404866 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0732184 | 0.025928 | 0.116345 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 39 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.0006679 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404880 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404882 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404892 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0775774 | 0.0193422 | 0.165244 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 28 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000680483 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404913 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404917 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6405124 | Piano 2 (+8.61) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0785399 | 0.0174119 | 0.185841 | 0.0544 | 0.05032 | 0.04117 | Piano Secondo | 25 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000683332 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6405232 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0811762 | 0.00996718 | 0.335547 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 14 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000690822 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405254 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405258 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405281 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405285 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405302 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 40 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 40
6405304 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 40 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 40
6405314 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0732184 | 0.025928 | 0.116345 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 39 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.0006679 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405328 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405330 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405340 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0775774 | 0.0193422 | 0.165244 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 28 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000680483 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405361 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
