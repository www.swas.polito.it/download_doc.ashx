Properties of the parts of a building model (IFC2X3), part 33 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6270766 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6270788 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 28 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6270808 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6270901 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.496895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0624417 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 12 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6270913 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6270972 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 25 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6270987 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.8095 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282442 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 24 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6271372 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.55884 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.894434 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 21 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6271728 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 42 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6271743 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 49 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0381 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6271761 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6271763 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 45 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6271765 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 42 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6271769 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 32 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6271777 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 41 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6271782 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 40 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6272598 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 49 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6272946 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 47 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273633 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 64 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273643 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 56 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0381 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6273647 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 59 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6273649 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 67 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6273651 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 64 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6273653 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 53 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273659 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 63 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273664 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 62 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273681 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 56 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273683 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 55 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273724 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 82 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273738 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 77 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6273740 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 85 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6273742 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 82 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6273744 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.841895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.105796 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 72 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273750 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 81 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273755 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 80 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273774 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 73 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273838 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.99527 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.752793 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 30 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6273863 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 51 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6276290 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 69 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6276313 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 88 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276671 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.46813 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.272386 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 347 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276674 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.52286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 336 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276686 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 336 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6276692 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 339 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6276694 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 334 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276697 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 335 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276704 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 342 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6276706 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 350 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6276708 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 347 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6276712 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 332 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276715 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 333 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276720 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.0774679 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00778792 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 346 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6276725 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3538 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23663 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 345 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278001 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.46813 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.272386 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 763 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278016 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 752 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6278022 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 755 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6278024 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 750 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278034 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 758 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6278036 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 766 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6278038 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 763 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6278042 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 748 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278045 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 749 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278050 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.0774679 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00778792 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 762 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278055 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 761 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278575 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.44742 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.27076 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 752 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278587 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.984139 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0772941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 752 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6278797 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6278800 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6278812 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 38 | Dati identità - Commenti: Stacco
6278818 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 38 | Dati identità - Commenti: Stacco
6278820 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6278823 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6278830 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 38 | Dati identità - Commenti: Stacco
6278832 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 28 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 38 | Dati identità - Commenti: Stacco
6278834 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 38 | Dati identità - Commenti: Stacco
6278838 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 12 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6278841 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6278846 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 25 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6278851 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 38 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 24 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 38
6279013 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279016 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279028 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279034 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279036 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279039 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279046 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279048 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 28 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279050 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279054 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 12 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279057 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279062 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 25 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279067 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 24 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279123 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 106 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279126 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 95 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279138 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 95 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279144 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 98 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279146 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 93 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279149 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 94 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279156 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 101 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279158 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 109 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279160 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 106 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279164 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 91 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279167 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 92 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279172 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 105 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279177 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 104 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279233 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 128 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279236 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 117 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279248 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 117 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279254 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 120 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279256 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 115 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279259 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 116 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279266 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 123 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279268 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 131 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279270 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 128 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279274 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 113 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279277 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 114 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279282 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 127 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279287 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 126 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279345 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 150 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279348 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.38294 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.030076 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3370 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279360 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3370 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
