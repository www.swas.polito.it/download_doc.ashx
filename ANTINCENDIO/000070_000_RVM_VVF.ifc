Properties of the parts of a building model (IFC2X3), part 3 of 58

# IfcFlowFitting: Standard (236)
Name (M_Croce - Filettata - MI - Classe 150:Standard:...) | In | Angolo 3 (deg) | Angolo 4 (deg) | Angolo 5 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Lunghezza 7 (m) | Lunghezza 8 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo 1 (deg) | Angolo 2 (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6324102 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 249 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324106 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324217 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 255 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324221 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324332 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 261 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324336 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324447 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 267 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324451 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324562 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 273 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324566 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324677 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 279 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324681 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324792 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324796 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6325713 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 288 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6325982 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 293 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6326120 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 300 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6326124 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6326890 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 305 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6326982 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 310 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327069 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 315 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327143 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 320 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327219 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 325 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327293 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 330 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327392 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 335 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327586 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 344 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327590 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327768 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 346 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329523 | Piano 3 (+12.85) | 89.9967 | 90 | 89.9967 | 0.0782 | 0.0643 | 0.1564 | 0.156396 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90.0033 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6330325 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6330503 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6330853 | Piano 3 (+12.85) | 89.9963 | 90 | 89.9963 | 0.0782 | 0.0643 | 0.1564 | 0.156395 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90.0037 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331822 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331930 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332091 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332213 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332334 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332467 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332583 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332706 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332804 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333008 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333282 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 84 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333286 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333447 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 83 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333519 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 101 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333583 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333636 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6377779 | PR_VVF_0200_SPR_Sezione su scala | 89.958 | 89.9227 | 89.9227 | 0.0782 | 0.0643 | 0.1564 | 0.156343 | 0.156295 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 90.042 | 90.0773 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.89632 | Dati identità - Commenti: Rampa 0-1
6379533 | PR_VVF_0200_SPR_Sezione su scala | 89.8119 | 89.8619 | 89.8119 | 0.0782 | 0.0643 | 0.1564 | 0.156657 | 0.156212 | 0.0781996 | 0.0781998 | 0.0544 | 0.05032 | Piano Terra | 89.8119 | 90.1381 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188324 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.25981 | Dati identità - Commenti: Rampa 0-1
6380814 | PR_VVF_0200_SPR_Sezione su scala | 89.9018 | 89.9687 | 89.9018 | 0.0782 | 0.0643 | 0.1564 | 0.156534 | 0.156357 | 0.0781999 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 89.9018 | 90.0313 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72377 | Dati identità - Commenti: Rampa 0-1
6381847 | PR_VVF_0200_SPR_Sezione su scala | 89.7968 | 89.681 | 89.681 | 0.0782 | 0.0643 | 0.1564 | 0.156677 | 0.155965 | 0.0781995 | 0.0781988 | 0.0544 | 0.05032 | Piano Terra | 89.7968 | 90.319 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.373 | Dati identità - Commenti: Rampa 0-1
6382934 | PR_VVF_0200_SPR_Sezione su scala | 89.9039 | 89.9917 | 89.9039 | 0.0782 | 0.0643 | 0.1564 | 0.156531 | 0.156411 | 0.0781999 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 89.9039 | 89.9917 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.9509 | Dati identità - Commenti: Rampa 0-1
6385702 | PR_VVF_0200_SPR_Sezione su scala | 89.835 | 89.9287 | 89.835 | 0.0782 | 0.0643 | 0.1564 | 0.156625 | 0.156303 | 0.0781997 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 89.835 | 90.0713 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.55161 | Dati identità - Commenti: Rampa 0-1
6385727 | PR_VVF_0200_SPR_Sezione su scala | 89.9487 | 89.9262 | 89.9262 | 0.0782 | 0.0643 | 0.1564 | 0.15647 | 0.156299 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 89.9487 | 90.0738 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14693 | Dati identità - Commenti: Rampa 0-1
6388202 | PR_VVF_0200_SPR_Sezione su scala | 89.8651 | 89.9988 | 89.8651 | 0.0782 | 0.0643 | 0.1564 | 0.156584 | 0.156402 | 0.0781998 | 0.0782 | 0.0544 | 0.05032 | VE4615 | 89.8651 | 89.9988 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43293 | Dati identità - Commenti: rampa 0-1
6388206 | PR_VVF_0200_SPR_Sezione su scala | 89.9501 | 89.8707 | 89.8707 | 0.0782 | 0.0643 | 0.1564 | 0.156468 | 0.156223 | 0.0782 | 0.0781998 | 0.0544 | 0.05032 | VE4616 | 89.9501 | 90.1293 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43319 | Dati identità - Commenti: rampa 0-1
6403059 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6403562 | Piano 2 (+8.61) | 89.8863 | 89.9232 | 89.8863 | 0.0782 | 0.0643 | 0.1564 | 0.156245 | 0.156505 | 0.0781998 | 0.0781999 | 0.0544 | 0.05032 | Piano Secondo | 90.1137 | 89.9232 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6404526 | Piano 2 (+8.61) | 89.908 | 89.8942 | 89.8942 | 0.0782 | 0.0643 | 0.1564 | 0.156274 | 0.156544 | 0.0781999 | 0.0781999 | 0.0544 | 0.05032 | Piano Secondo | 90.092 | 89.8942 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6404802 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6404829 | Piano 2 (+8.61) | 89.8863 | 89.9232 | 89.8863 | 0.0782 | 0.0643 | 0.1564 | 0.156245 | 0.156505 | 0.0781998 | 0.0781999 | 0.0544 | 0.05032 | Piano Secondo | 90.1137 | 89.9232 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6404909 | Piano 2 (+8.61) | 89.908 | 89.8942 | 89.8942 | 0.0782 | 0.0643 | 0.1564 | 0.156274 | 0.156544 | 0.0781999 | 0.0781999 | 0.0544 | 0.05032 | Piano Secondo | 90.092 | 89.8942 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6405148 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6405250 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6405277 | Piano 1 (+4.80) | 89.8863 | 89.9232 | 89.8863 | 0.0782 | 0.0643 | 0.1564 | 0.156245 | 0.156505 | 0.0781998 | 0.0781999 | 0.0544 | 0.05032 | Piano Primo | 90.1137 | 89.9232 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6405357 | Piano 1 (+4.80) | 89.908 | 89.8942 | 89.8942 | 0.0782 | 0.0643 | 0.1564 | 0.156274 | 0.156544 | 0.0781999 | 0.0781999 | 0.0544 | 0.05032 | Piano Primo | 90.092 | 89.8942 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6405853 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6407083 | Piano 1 (+4.80) | 89.9487 | 89.9262 | 89.9262 | 0.0782 | 0.0643 | 0.1564 | 0.15647 | 0.156299 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Primo | 89.9487 | 90.0738 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6407724 | PR_VVF_0200_SPR_Sezione su scala | 89.8863 | 89.9232 | 89.8863 | 0.0782 | 0.0643 | 0.1564 | 0.156245 | 0.156505 | 0.0781998 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 90.1137 | 89.9232 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6407987 | PR_VVF_0200_SPR_Sezione su scala | 89.9409 | 89.9227 | 89.9227 | 0.0782 | 0.0643 | 0.1564 | 0.156319 | 0.156295 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 90.0591 | 90.0773 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6408494 | PR_VVF_0200_SPR_Sezione su scala | 89.958 | 89.9227 | 89.9227 | 0.0782 | 0.0643 | 0.1564 | 0.156343 | 0.156295 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 90.042 | 90.0773 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.89632 | Dati identità - Commenti: Rampa 0-1
6408508 | PR_VVF_0200_SPR_Sezione su scala | 89.8119 | 89.8619 | 89.8119 | 0.0782 | 0.0643 | 0.1564 | 0.156657 | 0.156212 | 0.0781996 | 0.0781998 | 0.0544 | 0.05032 | Piano Terra | 89.8119 | 90.1381 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188324 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.25981 | Dati identità - Commenti: Rampa 0-1
6408524 | PR_VVF_0200_SPR_Sezione su scala | 89.9018 | 89.9687 | 89.9018 | 0.0782 | 0.0643 | 0.1564 | 0.156534 | 0.156357 | 0.0781999 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 89.9018 | 90.0313 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72377 | Dati identità - Commenti: Rampa 0-1
6408542 | PR_VVF_0200_SPR_Sezione su scala | 89.7968 | 89.681 | 89.681 | 0.0782 | 0.0643 | 0.1564 | 0.156677 | 0.155965 | 0.0781995 | 0.0781988 | 0.0544 | 0.05032 | Piano Terra | 89.7968 | 90.319 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.373 | Dati identità - Commenti: Rampa 0-1
6408561 | PR_VVF_0200_SPR_Sezione su scala | 89.9039 | 89.9917 | 89.9039 | 0.0782 | 0.0643 | 0.1564 | 0.156531 | 0.156411 | 0.0781999 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 89.9039 | 89.9917 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.9509 | Dati identità - Commenti: Rampa 0-1
6408577 | PR_VVF_0200_SPR_Sezione su scala | 89.835 | 89.9287 | 89.835 | 0.0782 | 0.0643 | 0.1564 | 0.156625 | 0.156303 | 0.0781997 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 89.835 | 90.0713 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.55161 | Dati identità - Commenti: Rampa 0-1
6408581 | PR_VVF_0200_SPR_Sezione su scala | 89.9487 | 89.9262 | 89.9262 | 0.0782 | 0.0643 | 0.1564 | 0.15647 | 0.156299 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 89.9487 | 90.0738 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14693 | Dati identità - Commenti: Rampa 0-1
6408668 | PR_VVF_0200_SPR_Sezione su scala | 89.8863 | 89.9232 | 89.8863 | 0.0782 | 0.0643 | 0.1564 | 0.156245 | 0.156505 | 0.0781998 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 90.1137 | 89.9232 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6408713 | PR_VVF_0200_SPR_Sezione su scala | 89.9409 | 89.9227 | 89.9227 | 0.0782 | 0.0643 | 0.1564 | 0.156319 | 0.156295 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 90.0591 | 90.0773 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00171155 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6409003 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6409030 | Piano 1 (+4.80) | 89.8863 | 89.9232 | 89.8863 | 0.0782 | 0.0643 | 0.1564 | 0.156245 | 0.156505 | 0.0781998 | 0.0781999 | 0.0544 | 0.05032 | Piano Primo | 90.1137 | 89.9232 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6409108 | Piano 1 (+4.80) | 89.908 | 89.8942 | 89.8942 | 0.0782 | 0.0643 | 0.1564 | 0.156274 | 0.156544 | 0.0781999 | 0.0781999 | 0.0544 | 0.05032 | Piano Primo | 90.092 | 89.8942 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6409140 | Piano 1 (+4.80) | 89.9487 | 89.9262 | 89.9262 | 0.0782 | 0.0643 | 0.1564 | 0.15647 | 0.156299 | 0.0782 | 0.0781999 | 0.0544 | 0.05032 | Piano Primo | 89.9487 | 90.0738 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3

# IfcFlowFitting: Standard (385)
Type - Altro - Categoria: Raccordi tubazione; Nome famiglia: M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150; Nome tabella di ricerca: M_Elbow Street - Threaded - MI - Class 150
Type - Dati identità - Commenti sul tipo: Gomito; Descrizione: Gomito; Nome del tipo: Standard; Numero OmniClass: 23.60.30.11.14; Titolo OmniClass: Pipework Fittings
Type - Meccanica - Metodo di perdita: Coefficiente K da tabella; Tabella di coefficienti K: Gomito filettato regolare 45, 90 e 180
Pset_DistributionFlowElementCommon - Reference: Standard
Altro - Famiglia: M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150: Standard; Famiglia e tipo: M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150: Standard; ID tipo: M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150: Standard; Tipo: M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150: Standard
Fasi - Fase di creazione: Stato di Progetto
Grafica - Utilizza scala di annotazione: yes
Isolamento - Spessore isolamento: 0 m
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco; Classificazione sistema: Protezione antincendio a secco
Name (M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150:Standard:...) | In | Da centro a estremità 1 (m) | Da centro a estremità 2 (m) | Da centro a estremità maschio 1 (m) | Da centro a estremità maschio 2 (m) | Lunghezza 1 (m) = Lunghezza 5 (m) | Lunghezza 2 (m) | Lunghezza 3 (m) | Lunghezza 4 (m) | Raggio centro (m) | Raggio esterno banda (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Contrassegno | Angolo (deg) | Da centro a estremità (m) | Da centro a estremità maschio (m) | Diametro esterno banda (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Diametro porta estremità maschio (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Lunghezza filettatura esterna (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6270585 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6271071 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6271789 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6272950 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273671 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273685 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273762 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6276688 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6276732 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6278018 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6278062 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6278814 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 38
6278858 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 38
6279030 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279074 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279140 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279184 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279250 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279294 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279362 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279406 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279474 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279518 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279584 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279628 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279694 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279738 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279804 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279848 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279918 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279962 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280028 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280072 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280138 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280182 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280250 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280358 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280402 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Secondo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 132 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 132 | Meccanico - Flusso - Caduta pressione: 0 Pa
