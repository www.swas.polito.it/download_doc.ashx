Properties of the parts of a building model (IFC2X3), part 29 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6326805 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 35
6326861 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 299 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 299
6326865 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 301 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6326868 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 298 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 298
6326872 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 298 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 298 | Meccanico - Flusso - Caduta pressione: 0 Pa
6326877 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 299 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 299
6326883 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 299 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 299
6326888 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 305 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 305
6326892 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 305 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 305
6326953 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 303 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 303
6326957 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 304 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6326960 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 302 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 302
6326964 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 302 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 302 | Meccanico - Flusso - Caduta pressione: 0 Pa
6326969 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 303 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 303
6326975 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 303 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 303
6326980 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 310 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 310
6326984 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 310 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 310
6327040 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 308 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 308
6327044 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 309 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6327047 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 306 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 306
6327051 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 306 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 306 | Meccanico - Flusso - Caduta pressione: 0 Pa
6327056 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 308 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 308
6327062 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 308 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 308
6327067 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 315 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 315
6327071 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 315 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 315
6327114 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 313 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 313
6327118 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 314 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6327121 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 311 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 311
6327125 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 311 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 311 | Meccanico - Flusso - Caduta pressione: 0 Pa
6327130 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 313 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 313
6327136 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 313 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 313
6327141 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 320 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 320
6327145 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 320 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 320
6327190 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 318 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 318
6327194 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 319 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6327197 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 316 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 316
6327201 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 316 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 316 | Meccanico - Flusso - Caduta pressione: 0 Pa
6327206 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 318 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 318
6327212 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 318 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 318
6327217 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 325 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 325
6327221 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 325 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 325
6327264 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 323 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 323
6327268 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 324 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6327271 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 321 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 321
6327275 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 321 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 321 | Meccanico - Flusso - Caduta pressione: 0 Pa
6327280 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 323 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 323
6327286 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 323 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 323
6327291 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 330 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 330
6327295 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 330 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 330
6327363 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 328 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 328
6327367 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 329 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6327370 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 326 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 326
6327374 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 326 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 326 | Meccanico - Flusso - Caduta pressione: 0 Pa
6327379 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 328 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 328
6327385 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 328 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 328
6327390 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 335 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 335
6327394 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 335 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 335
6327541 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 333 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 333
6327545 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 336 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6327547 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6327559 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 331 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 331
6327563 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 331 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 331 | Meccanico - Flusso - Caduta pressione: 0 Pa
6327570 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 333 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 333
6327576 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 333 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 333
6327581 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 344 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 344
6327588 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 344 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 344
6327592 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6327594 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6327598 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6327739 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 340 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 340
6327743 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 341 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6327746 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 338 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 338
6327750 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 338 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 338 | Meccanico - Flusso - Caduta pressione: 0 Pa
6327755 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 340 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 340
6327761 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 340 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 340
6327766 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 346 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 346
6327770 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 346 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 346
6328753 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6328891 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6328966 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329036 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329103 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329242 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329441 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329629 | Piano 3 (+12.85) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329707 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329720 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329746 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329758 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329771 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329845 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329858 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329884 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329897 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329910 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329923 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329981 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6329994 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6330205 | Piano 3 (+12.85) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6330252 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 344 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 344 | Meccanico - Flusso - Caduta pressione: 0 Pa
6330297 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 26 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 26
