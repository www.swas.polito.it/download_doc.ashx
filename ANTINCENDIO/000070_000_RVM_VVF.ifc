Properties of the parts of a building model (IFC2X3), part 34 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6279366 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 142 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279368 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 137 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279371 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 138 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279378 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 145 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279380 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 153 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279382 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 150 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279386 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 135 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279389 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 136 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279394 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 149 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279399 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.293441 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0294999 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3367 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279457 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 172 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279460 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 161 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279472 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 161 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279478 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 164 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279480 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 159 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279483 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 160 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279490 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 167 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279492 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 175 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279494 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 172 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279498 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 157 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279501 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 158 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279506 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 171 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279511 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 170 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279567 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 194 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279570 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 183 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279582 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 183 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279588 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 186 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279590 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 181 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279593 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 182 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279600 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 189 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279602 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 197 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279604 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 194 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279608 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 179 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279611 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 180 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279616 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 193 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279621 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 192 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279677 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 216 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279680 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 205 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279692 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 205 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279698 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 208 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279700 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 203 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279703 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 204 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279710 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 211 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279712 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 219 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279714 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 216 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279718 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 201 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279721 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 202 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279726 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 215 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279731 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 214 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279787 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 238 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279790 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 227 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279802 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 227 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279808 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 230 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279810 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 225 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279813 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 226 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279820 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 233 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279822 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 241 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279824 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 238 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279828 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 223 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279831 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 224 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279836 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 237 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279841 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 236 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279901 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 260 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279904 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.2426 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0190538 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 249 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279916 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 249 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279922 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 252 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279924 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 247 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279927 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 248 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279934 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 255 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279936 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 263 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279938 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 260 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6279942 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 245 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279945 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 246 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279950 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 259 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6279955 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.22674 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0227944 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 258 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280011 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 282 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280014 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 271 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280026 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 271 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280032 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 274 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280034 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 269 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280037 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 270 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280044 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 277 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280046 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 285 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280048 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 282 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280052 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 267 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280055 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 268 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280060 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 281 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280065 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 280 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280121 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 304 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280124 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 293 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280136 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 293 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280142 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 296 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280144 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 291 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280147 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 292 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280154 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 299 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280156 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 307 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280158 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 304 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280162 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 289 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280165 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 290 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280170 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 303 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280175 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3338 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23462 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 302 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280236 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 315 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280248 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 315 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280254 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 318 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280256 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 313 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280259 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 314 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280266 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 321 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280274 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 311 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280277 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 312 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280344 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 363 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280356 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 363 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280362 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 366 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280364 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 361 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280367 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 362 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280374 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 369 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6280378 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 132 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 374 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 132 | Dati identità - Commenti: Stacco
6280382 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 359 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280385 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 360 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280455 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 515 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6280458 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 504 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
