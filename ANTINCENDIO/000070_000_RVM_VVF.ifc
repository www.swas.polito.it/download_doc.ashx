Properties of the parts of a building model (IFC2X3), part 50 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6325953 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 53 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 53 | Dati identità - Commenti: Stacco
6325962 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 286 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 286
6325967 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 286 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 286 | Dati identità - Commenti: Stacco
6325972 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 286 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 286 | Dati identità - Commenti: Stacco
6325978 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 293 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 293 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6326032 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.585673 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0588783 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2116 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6326079 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 290 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 290 | Dati identità - Commenti: Stacco
6326085 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2094 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6326089 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 300 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 300
6326093 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.485 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.35035 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 300 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 300
6326097 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 291 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 291
6326107 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 291 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 6 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 291 | Dati identità - Commenti: Stacco
6326113 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 300 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 300 | Dati identità - Commenti: Stacco
6326118 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2091 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6326130 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2093 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6326216 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.411421 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0517007 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2096 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6326400 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.0988 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00775973 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 291 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 291
6326423 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.71424 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213176 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 291 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 291
6326434 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.03396 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00266721 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 291 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 291
6326629 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.0853596 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00670413 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 291 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 291
6326684 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 291 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 291 | Dati identità - Commenti: Stacco
6326707 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.6411 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.207432 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2041 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6326717 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2042 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6326765 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.6411 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.207432 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2029 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6326775 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2030 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6326798 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.6411 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.207432 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2022 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6326808 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2023 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6326859 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.7163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213338 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 299 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 299
6326863 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 298 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 298 | Dati identità - Commenti: Stacco
6326870 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 299 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 299
6326875 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 299 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 299 | Dati identità - Commenti: Stacco
6326880 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 299 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 299 | Dati identità - Commenti: Stacco
6326886 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 305 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 305 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6326894 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.197521 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.019857 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2744 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6326951 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.7163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213338 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 303 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 303
6326955 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 302 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 302 | Dati identità - Commenti: Stacco
6326962 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 303 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 303
6326967 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 303 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 303 | Dati identità - Commenti: Stacco
6326972 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 303 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 303 | Dati identità - Commenti: Stacco
6326978 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 310 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 310 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6326986 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.199991 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0201052 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2741 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327038 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.7163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213338 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 308 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 308
6327042 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 306 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 306 | Dati identità - Commenti: Stacco
6327049 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 308 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 308
6327054 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 308 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 308 | Dati identità - Commenti: Stacco
6327059 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 308 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 308 | Dati identità - Commenti: Stacco
6327065 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 315 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 315 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6327073 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.199991 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0201052 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2738 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327112 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.7163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213338 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 313 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 313
6327116 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 311 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 311 | Dati identità - Commenti: Stacco
6327123 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 313 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 313
6327128 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 313 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 313 | Dati identità - Commenti: Stacco
6327133 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 313 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 313 | Dati identità - Commenti: Stacco
6327139 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 320 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 320 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6327147 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.199991 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0201052 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2407 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327188 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.7163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213338 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 318 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 318
6327192 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 316 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 316 | Dati identità - Commenti: Stacco
6327199 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 318 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 318
6327204 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 318 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 318 | Dati identità - Commenti: Stacco
6327209 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 318 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 318 | Dati identità - Commenti: Stacco
6327215 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 325 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 325 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6327223 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.19575 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.019679 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2372 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327262 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.7163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213338 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 323 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 323
6327266 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 321 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 321 | Dati identità - Commenti: Stacco
6327273 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 323 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 323
6327278 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 323 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 323 | Dati identità - Commenti: Stacco
6327283 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 323 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 323 | Dati identità - Commenti: Stacco
6327289 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 330 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 330 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6327297 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.19575 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.019679 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327361 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.7163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.213338 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 328 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 328
6327365 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 326 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 326 | Dati identità - Commenti: Stacco
6327372 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 328 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 328
6327377 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 328 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 328 | Dati identità - Commenti: Stacco
6327382 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 328 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 328 | Dati identità - Commenti: Stacco
6327388 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 335 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 335 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6327396 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.19575 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.019679 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2038 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327538 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.0163 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.2369 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 333 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 333
6327543 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 331 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 331 | Dati identità - Commenti: Stacco
6327549 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2054 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6327553 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 344 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 344
6327557 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 344 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 344
6327561 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 333 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 333
6327568 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 333 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 333 | Dati identità - Commenti: Stacco
6327573 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 333 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 333 | Dati identità - Commenti: Stacco
6327579 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 344 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 344 | Dati identità - Commenti: Stacco
6327584 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2051 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6327596 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2053 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6327696 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.418579 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0526002 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2056 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327737 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.6763 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.288736 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 340 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 340
6327741 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 338 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 338 | Dati identità - Commenti: Stacco
6327748 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 340 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 340
6327753 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 340 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 340 | Dati identità - Commenti: Stacco
6327758 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 340 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 340 | Dati identità - Commenti: Stacco
6327764 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 346 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 346 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6327827 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 1.05624 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.106185 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 35 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6327838 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 9.76737 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.981923 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 35 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6328730 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.342675 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0861236 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2019 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6328742 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2025 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6328880 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2032 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6328943 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.726268 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.182531 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2037 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6328959 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.24895 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.313896 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2028 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329082 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.165711 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0416476 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2047 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329092 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2044 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6329096 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.13162 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.535735 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2035 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329223 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.16412 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0412478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2311 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329235 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.36642 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.594747 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2040 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329434 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.827372 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.207941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2049 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329700 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0052 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.755289 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2058 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329713 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.0165428 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00415765 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2076 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329751 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.477526 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.120015 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2118 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329764 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.47909 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.371737 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2121 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329838 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.941405 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.236601 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2137 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
