Properties of the parts of a building model (IFC2X3), part 9 of 58

# IfcFlowFitting: Standard (475)
Name (M_Raccordo a T - Filettato - MI - Classe 150:Standard:...) | In | Angolo 1 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6309982 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310022 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310482 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310547 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310650 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310707 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310746 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310791 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310842 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6310885 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312036 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312075 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312114 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312153 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312192 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312231 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312270 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312422 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312463 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312790 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312890 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312903 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312916 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312937 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312950 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312963 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312976 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6312989 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6313471 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6315038 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Mandata di sistema idronico | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6315333 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Mandata di sistema idronico | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318248 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 6 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318365 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 13 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318484 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 19 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318603 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 25 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318722 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 31 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318837 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 42 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318964 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 48 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319113 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 54 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319234 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 56 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319351 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 61 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319470 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 66 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319587 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 73 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319708 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 79 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319852 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 86 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320350 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 92 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320467 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 98 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320586 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 104 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320703 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 110 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320822 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 116 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320937 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 122 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321056 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 128 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321437 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 95 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321566 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 107 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321716 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 125 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321833 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 135 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321950 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 145 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322081 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 152 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322244 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 157 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322359 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 162 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322474 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 167 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322589 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 172 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322704 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 177 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322819 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 182 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322934 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 187 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323049 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 192 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323164 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 197 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323279 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 202 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323404 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 207 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323721 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 219 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323858 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 227 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323973 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 233 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324088 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 239 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324203 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 245 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324318 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 251 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324433 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 257 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324548 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 263 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324663 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 269 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6324778 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 275 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6325702 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 282 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6325971 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 286 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6326683 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 291 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6326879 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 299 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6326971 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 303 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327058 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 308 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327132 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 313 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327208 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 318 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327282 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 323 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327381 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 328 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327572 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 333 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6327757 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 340 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6328741 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6328745 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6328879 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6328883 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6328958 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329028 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329091 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329095 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329234 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329699 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329712 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329738 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329750 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329763 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329837 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329850 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329876 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329889 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329902 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329915 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6329973 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6330197 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6330314 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 26 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6330408 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331260 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331266 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331284 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331297 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331307 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331316 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331329 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331342 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331355 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331438 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331483 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331496 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331536 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331713 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331794 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6331909 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332930 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332952 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332965 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6332978 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333130 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333169 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333208 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333268 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 14 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333371 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333393 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333436 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 59 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333508 | Piano 3 (+12.85) | 90 | 0.0381 | 0.0304 | 0.0762 | 0.0762 | 0.0381 | 0.0225 | 0.0201 | Piano Uffici | 90 | 0.045 | 0.0402 | 0.0334 | 0.025 | 0.01608 | ø25xø25xø25 | 0.0077 | 0.0125 | 0.0034 | 0.000130832 | ø25 mmxø25 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 76 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333674 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6333686 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Uffici | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6387927 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Dati identità - Commenti: Rampa 0-1
6402664 | Piano 2 (+8.61) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6404146 | Piano 2 (+8.61) | 89.896 | 0.0782 | 0.0643 | 0.1564 | 0.156542 | 0.0781999 | 0.0544 | 0.05032 | Piano Secondo | 89.896 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
