Properties of the parts of a building model (IFC2X3), part 10 of 58

# IfcFlowFitting: Standard (475)
Name (M_Raccordo a T - Filettato - MI - Classe 150:Standard:...) | In | Angolo 1 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6404365 | Piano 2 (+8.61) | 89.9562 | 0.0782 | 0.0643 | 0.1564 | 0.15634 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90.0438 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6404858 | Piano 2 (+8.61) | 89.896 | 0.0782 | 0.0643 | 0.1564 | 0.156542 | 0.0781999 | 0.0544 | 0.05032 | Piano Secondo | 89.896 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6404884 | Piano 2 (+8.61) | 89.9562 | 0.0782 | 0.0643 | 0.1564 | 0.15634 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90.0438 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6405130 | Piano 2 (+8.61) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6405332 | Piano 1 (+4.80) | 89.9562 | 0.0782 | 0.0643 | 0.1564 | 0.15634 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90.0438 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6405743 | Piano 1 (+4.80) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6406500 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6406548 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6406594 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6406789 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6406807 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6406820 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6407753 | PR_VVF_0200_SPR_Sezione su scala | 89.896 | 0.0782 | 0.0643 | 0.1564 | 0.156542 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 89.896 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6408697 | PR_VVF_0200_SPR_Sezione su scala | 89.896 | 0.0782 | 0.0643 | 0.1564 | 0.156542 | 0.0781999 | 0.0544 | 0.05032 | Piano Terra | 89.896 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6408925 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Dati identità - Commenti: Rampa 0-1
6409083 | Piano 1 (+4.80) | 89.9562 | 0.0782 | 0.0643 | 0.1564 | 0.15634 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90.0438 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6409267 | Piano 1 (+4.80) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6410903 | PR_VVF_0200_SPR_Sezione su scala | 89.9985 | 0.0963 | 0.0795 | 0.1926 | 0.192598 | 0.0963 | 0.0686 | 0.06393 | Piano Terra | 90.0015 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6410977 | PR_VVF_0200_SPR_Sezione su scala | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.8
6411021 | Piano 1 (+4.80) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6411255 | Piano 3 (+12.85) | 89.9514 | 0.0963 | 0.0795 | 0.1926 | 0.192682 | 0.0963 | 0.0686 | 0.06393 | Piano Uffici | 89.9514 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6418777 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | VE5405 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6418997 | Piano 3 (+12.85) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | VE5419 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6419120 | Piano 2 (+8.61) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | VE5422 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6419188 | Piano 2 (+8.61) | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.0782 | 0.0544 | 0.05032 | VE5433 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00158234 | ø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3

# IfcFlowFitting: Standard (2277)
Type - Altro - Categoria: Raccordi tubazione; Nome famiglia: M_Riduzione concentrica innesto - Filettata - MI - Classe 150; Nome tabella di ricerca: M_Coupling Concentric Reducing - Threaded - MI - Class 150
Type - Dati identità - Commenti sul tipo: Riduzione; Descrizione: Riduzione; Nome del tipo: Standard; Numero OmniClass: 23.60.30.11.14; Titolo OmniClass: Pipework Fittings
Type - Meccanica - Metodo di perdita: Coefficiente K da tabella; Tabella di coefficienti K: Transizione contrazione/ingrandimento
Pset_DistributionFlowElementCommon - Reference: Standard
Altro - Famiglia: M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard; Famiglia e tipo: M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard; ID tipo: M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard; Visibilità 3: no
Fasi - Fase di creazione: Stato di Progetto
Grafica - Utilizza scala di annotazione: yes
Isolamento - Spessore isolamento: 0 m
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6269170 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6270084 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6270355 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6270624 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36 | Meccanico - Flusso - Caduta pressione: 0 Pa
6270690 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 36
6270764 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36 | Meccanico - Flusso - Caduta pressione: 0 Pa
6270871 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6270920 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 36
6270983 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6270994 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 36
6271069 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6271566 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6271626 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6271736 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6271739 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6271759 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6271775 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 36
6271779 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6271785 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 36
6271787 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6271793 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6271860 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6271862 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6272954 | Piano 2 (+8.61) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273639 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6273641 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273645 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6273657 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 36
6273661 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6273667 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 36
6273669 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6273675 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273677 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273679 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273687 | Piano 2 (+8.61) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273732 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273736 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6273748 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 36
6273752 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6273758 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 36
6273760 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 36
6273766 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273894 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6273905 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6276679 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6276682 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6276684 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6276690 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6276700 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6276702 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6276710 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6276718 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6276722 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6276728 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6276730 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6278009 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6278012 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6278020 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6278030 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6278032 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6278040 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6278048 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6278052 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6278058 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6278060 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6278066 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6278068 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6278805 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 38
6278808 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 38
6278810 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 38
6278816 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 38 | Meccanico - Flusso - Caduta pressione: 0 Pa
6278826 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 38
6278828 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 38
6278836 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 38
6278844 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 38
6278848 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 38
6278854 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 38
6278856 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 38
6278862 | Piano 2 (+8.61) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 38
6278864 | Piano 2 (+8.61) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 38
6279021 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6279024 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
