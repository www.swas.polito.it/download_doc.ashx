Properties of the parts of a building model (IFC2X3), part 45 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6318688 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 31 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 31
6318693 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 28 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 28 | Dati identità - Commenti: Stacco
6318699 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2210 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318701 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.34408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.294566 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2203 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6318703 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 41 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 41
6318707 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.305 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332255 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 41 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 41
6318711 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 31 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 31
6318718 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 31 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 31 | Dati identità - Commenti: Stacco
6318723 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 31 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 31 | Dati identità - Commenti: Stacco
6318729 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 46 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 46 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6318734 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2207 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318746 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2209 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6318803 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 42 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 42
6318808 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 34 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 34 | Dati identità - Commenti: Stacco
6318814 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2168 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318816 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.34408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.294566 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2161 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6318818 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 47 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 47
6318822 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.305 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332255 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 47 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 47
6318826 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 42 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 42
6318833 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 42 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 42 | Dati identità - Commenti: Stacco
6318838 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 42 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 42 | Dati identità - Commenti: Stacco
6318844 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 52 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 52 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6318849 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2165 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318861 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2167 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6318930 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 5.0963 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.400263 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 48 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 48
6318935 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 45 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 45 | Dati identità - Commenti: Stacco
6318941 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2142 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318943 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.404081 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0507783 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2135 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6318945 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 58 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 58
6318949 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.485 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.35035 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 58 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 58
6318953 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 48 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 48
6318960 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 48 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 48 | Dati identità - Commenti: Stacco
6318965 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 48 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 48 | Dati identità - Commenti: Stacco
6318971 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 58 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 58 | Dati identità - Commenti: Stacco
6318976 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2139 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318988 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2141 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6319084 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.33786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262155 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 54 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 54
6319090 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 51 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 51 | Dati identità - Commenti: Stacco
6319092 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 54 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 54
6319096 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.689092 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0865939 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2334 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319100 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 57 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6319103 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2339 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319106 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 51 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 22 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 51 | Dati identità - Commenti: Stacco
6319109 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 54 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 54 | Dati identità - Commenti: Stacco
6319114 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 54 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 54 | Dati identità - Commenti: Stacco
6319127 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.30948 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332705 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2342 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319129 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2341 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319140 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 65 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 65 | Dati identità - Commenti: Stacco
6319144 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 67 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6319205 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.33786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262155 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 56 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 56
6319211 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 55 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 55 | Dati identità - Commenti: Stacco
6319213 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 56 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 56
6319217 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.689092 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0865939 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2318 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319221 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 62 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6319224 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2323 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319227 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 55 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 22 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 55 | Dati identità - Commenti: Stacco
6319230 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 56 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 56 | Dati identità - Commenti: Stacco
6319235 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 56 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 56 | Dati identità - Commenti: Stacco
6319248 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.30948 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332705 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2326 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319250 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2325 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319261 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 72 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 72 | Dati identità - Commenti: Stacco
6319265 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 74 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6319322 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.33786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262155 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 61 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 61
6319328 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 60 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 60 | Dati identità - Commenti: Stacco
6319330 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 61 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 61
6319334 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.689092 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0865939 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2257 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319338 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 68 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6319341 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2262 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319344 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 60 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 22 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 60 | Dati identità - Commenti: Stacco
6319347 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 61 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 61 | Dati identità - Commenti: Stacco
6319352 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 61 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 61 | Dati identità - Commenti: Stacco
6319365 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.30948 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332705 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2265 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319367 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2264 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319378 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 78 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 78 | Dati identità - Commenti: Stacco
6319382 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 81 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6319441 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.33786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262155 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 66 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 66
6319447 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 64 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 64 | Dati identità - Commenti: Stacco
6319449 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 66 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 66
6319453 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.689092 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0865939 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2248 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319457 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 75 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6319460 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2253 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319463 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 64 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 22 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 64 | Dati identità - Commenti: Stacco
6319466 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 66 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 66 | Dati identità - Commenti: Stacco
6319471 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 66 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 66 | Dati identità - Commenti: Stacco
6319484 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.30948 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332705 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2256 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319486 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2255 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319497 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 85 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 85 | Dati identità - Commenti: Stacco
6319501 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 87 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6319558 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.33786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262155 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 73 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 73
6319564 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 71 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 71 | Dati identità - Commenti: Stacco
6319566 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 73 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 73
6319570 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.689092 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0865939 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2239 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319574 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 82 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6319577 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2244 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319580 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 71 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 22 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 71 | Dati identità - Commenti: Stacco
6319583 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 73 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 73 | Dati identità - Commenti: Stacco
6319588 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 73 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 73 | Dati identità - Commenti: Stacco
6319601 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.30948 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332705 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2247 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319603 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2246 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319614 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 91 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 91 | Dati identità - Commenti: Stacco
6319618 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 93 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6319679 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 79 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 79
6319685 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2223 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319687 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 79 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 79
6319691 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.45941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.309059 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2213 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319695 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 88 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6319698 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2218 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319701 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2226 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319704 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 79 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 79 | Dati identità - Commenti: Stacco
6319709 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 79 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 79 | Dati identità - Commenti: Stacco
6319722 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2221 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319724 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2220 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319735 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 97 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 97 | Dati identità - Commenti: Stacco
6319739 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 99 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6319823 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 86 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 86
