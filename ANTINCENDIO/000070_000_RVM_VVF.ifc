Properties of the parts of a building model (IFC2X3), part 6 of 58

# IfcFlowFitting: Standard (385)
Name (M_Gomito con filettatura maschio e femmina - Filettato - MI - Classe 150:Standard:...) | In | Da centro a estremità 1 (m) | Da centro a estremità 2 (m) | Da centro a estremità maschio 1 (m) | Da centro a estremità maschio 2 (m) | Lunghezza 1 (m) = Lunghezza 5 (m) | Lunghezza 2 (m) | Lunghezza 3 (m) | Lunghezza 4 (m) | Raggio centro (m) | Raggio esterno banda (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Contrassegno | Angolo (deg) | Da centro a estremità (m) | Da centro a estremità maschio (m) | Diametro esterno banda (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Diametro porta estremità maschio (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Lunghezza filettatura esterna (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6405365 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405737 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0785399 | 0.0174119 | 0.185841 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 25 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000683332 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406508 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406556 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406602 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6407405 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0799111 | 0.0141028 | 0.233452 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 20.0172 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000687217 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.8 | Protezione antincendio a secco 35
6407409 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0720741 | 0.0272806 | 0.108849 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 41.4641 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000665073 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.42443 | Protezione antincendio a secco 35
6407728 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6407732 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6407749 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6407751 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6407761 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0732184 | 0.025928 | 0.116345 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 39 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.0006679 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6408125 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0811785 | 0.009958 | 0.335866 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 13.9868 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000690828 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6408402 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408404 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 108 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 108 | Dati identità - Commenti: Rampa 0-1
6408420 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 120 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.23232 | Protezione antincendio a secco 120 | Dati identità - Commenti: Rampa 0-1
6408422 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.25982 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408446 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37298 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408474 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 156 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.52527 | Protezione antincendio a secco 156 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6408476 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 161 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.52521 | Protezione antincendio a secco 161 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6408490 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 176 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.12 | Protezione antincendio a secco 176 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6408492 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14692 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408498 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0303995 | 0.0304 | 0.0303995 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90.0009 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626241 | ø25 mmxø25 mm | Protezione antincendio a secco 90 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.91126 | Protezione antincendio a secco 90 | Dati identità - Commenti: Rampa 0-1
6408502 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304037 | 0.0304 | 0.0304037 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 89.9931 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626264 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.89649 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408506 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0741609 | 0.0247188 | 0.123608 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 36.8678 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000670631 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.06967 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408522 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0703907 | 0.0290748 | 0.0997462 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 44.886 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000660268 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.49439 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408528 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72375 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408530 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72378 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408540 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0643 | 0.01982 | 0.109131 | 0.0460946 | 0.152232 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 45.7965 | 0.0782 | 0.1146 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.00102813 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.22246 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408550 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0303889 | 0.0304 | 0.0303889 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90.0209 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626218 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37281 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408569 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304018 | 0.0304 | 0.0304018 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 89.9966 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626254 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95102 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408571 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304055 | 0.0304 | 0.0304055 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 89.9897 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626274 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95099 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408573 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0753442 | 0.0230567 | 0.134633 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 34.0301 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000674085 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.02789 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408575 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0643 | 0.01982 | 0.105141 | 0.0496641 | 0.136126 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 50.5681 | 0.0782 | 0.1146 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.00101698 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.74884 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408607 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0751736 | 0.0233073 | 0.132883 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 34.4518 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000673593 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408672 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408676 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408693 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408695 | PR_VVF_0200_SPR_Sezione su scala | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Terra | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408705 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0732184 | 0.025928 | 0.116345 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 39 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.0006679 | ø80 mmxø80 mm | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408717 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0811785 | 0.009958 | 0.335866 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 13.9868 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000690828 | ø80 mmxø80 mm | Protezione antincendio a secco 114 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 114
6408985 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0811762 | 0.00996718 | 0.335547 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 14 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000690822 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409007 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409011 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409034 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409038 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409055 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 151 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 151
6409057 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 166 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 166
6409065 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0732184 | 0.025928 | 0.116345 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 39 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.0006679 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409079 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409081 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409091 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0775774 | 0.0193422 | 0.165244 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 28 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000680483 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409112 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409116 | Piano 1 (+4.80) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | Piano Primo | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409134 | Piano 1 (+4.80) | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0785399 | 0.0174119 | 0.185841 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 25 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000683332 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6409146 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0799111 | 0.0141028 | 0.233452 | 0.0544 | 0.05032 | 0.04117 | Piano Primo | 20.0172 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000687217 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.8 | Protezione antincendio a secco 35
6409148 | PR_VVF_0200_SPR_Sezione su scala | 0.0782 | 0.0551 | 0.1146 | 0.0762 | 0.0412 | 0.00452 | 0.0720741 | 0.0272806 | 0.108849 | 0.0544 | 0.05032 | 0.04117 | Piano Terra | 41.4641 | 0.0551 | 0.0762 | 0.1088 | 0.10064 | 0.08234 | 0.0889 | 0.08 | 0.0706 | 0.040256 | ø80xø80 | 0.0139 | 0.03048 | 0.04 | 0.00587 | 0.000665073 | ø80 mmxø80 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.42443 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa
6410812 | PR_VVF_0200_SPR_Sezione su scala | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Terra | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.7 | Protezione antincendio a secco 35
6410834 | PR_VVF_0200_SPR_Sezione su scala | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Terra | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.7 | Protezione antincendio a secco 35
6410899 | PR_VVF_0200_SPR_Sezione su scala | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Terra | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.68611 | Protezione antincendio a secco 35
6411439 | PR_VVF_0200_SPR_Sezione su scala | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Secondo | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 11.61 | Protezione antincendio a secco 35
6411556 | Piano 1 (+4.80) | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | Piano Uffici | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 11.55 | Protezione antincendio a secco 35
6413460 | PR_VVF_0200_SPR_Sezione su scala | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | VE5396 | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6413858 | PR_VVF_0200_SPR_Sezione su scala | 0.0963 | 0.0663 | 0.1445 | 0.094 | 0.0795 | 0.03198 | 0.0795 | 0.0795 | 0.0795 | 0.0686 | 0.06393 | 0.05373 | VE5399 | 90 | 0.0963 | 0.1445 | 0.1372 | 0.12786 | 0.10746 | 0.1144 | 0.1 | 0.094 | 0.051144 | ø100xø100 | 0.0168 | 0.03302 | 0.05 | 0.00673 | 0.00187465 | ø100 mmxø100 mm | Protezione antincendio a secco 35 | impianto a umido | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.7 | Protezione antincendio a secco 35
6418803 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5411 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6418805 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5412 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6418968 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5418 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6419007 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5420 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6419167 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5428 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419198 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5437 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419297 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5441 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419307 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5442 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419319 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5444 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419321 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5445 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419428 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5453 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419430 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5450 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419432 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5451 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419434 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5447 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419583 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5458 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419585 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5452 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419589 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5455 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419591 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5456 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419683 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5459 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419695 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5460 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419707 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5462 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6419709 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5463 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6420844 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5466 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6420878 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5468 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6420891 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5470 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6420893 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5471 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6421224 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5475 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6421268 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5482 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6421281 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5484 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6421283 | Piano 2 (+8.61) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5485 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6422034 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5502 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422133 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5523 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422148 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5525 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422150 | Piano 3 (+12.85) | 0.0445 | 0.0328 | 0.0622 | 0.0434 | 0.0358 | 0.00846 | 0.0358 | 0.0358 | 0.0358 | 0.02735 | 0.02478 | 0.01878 | VE5526 | 90 | 0.0445 | 0.0622 | 0.0547 | 0.04956 | 0.03756 | 0.0422 | 0.032 | 0.0302 | 0.019824 | ø32xø32 | 0.0087 | 0.01794 | 0.016 | 0.00368 | 0.000112842 | ø32 mmxø32 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422483 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5530 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422575 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5531 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422596 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5535 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422598 | Piano 3 (+12.85) | 0.0493 | 0.0363 | 0.0683 | 0.0478 | 0.04 | 0.00992 | 0.04 | 0.04 | 0.04 | 0.0308 | 0.02809 | 0.02154 | VE5536 | 90 | 0.0493 | 0.0683 | 0.0616 | 0.05618 | 0.04308 | 0.0483 | 0.04 | 0.0352 | 0.022472 | ø40xø40 | 0.0093 | 0.01838 | 0.02 | 0.00394 | 0.000162531 | ø40 mmxø40 mm | Protezione antincendio a secco 35 |  | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6422640 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5537 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6422672 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5540 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6422685 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5542 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6422687 | Piano 2 (+8.61) | 0.0381 | 0.0285 | 0.0544 | 0.0373 | 0.0304 | 0.00666 | 0.0304 | 0.0304 | 0.0304 | 0.0225 | 0.0201 | 0.01495 | VE5543 | 90 | 0.0381 | 0.0544 | 0.045 | 0.0402 | 0.0299 | 0.0334 | 0.025 | 0.0231 | 0.01608 | ø25xø25 | 0.0077 | 0.01734 | 0.0125 | 0.0034 | 0.0000626244 | ø25 mmxø25 mm | Protezione antincendio a secco 35 |  | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35

# IfcFlowFitting: Standard, M_Innesto - Filettato - MI - Classe 150:Standard:6326402
In: Piano 3 (+12.85)
Type - Altro - Categoria: Raccordi tubazione; Nome famiglia: M_Innesto - Filettato - MI - Classe 150; Nome tabella di ricerca: M_Coupling - Threaded - MI - Class 150
Type - Dati identità - Nome del tipo: Standard; Numero OmniClass: 23.60.30.11.14; Titolo OmniClass: Pipework Fittings
Type - Meccanica - Metodo di perdita: Coefficiente K da tabella; Tabella di coefficienti K: Riduttore/Innesto/Unione/Riduzione
Pset_DistributionFlowElementCommon - Reference: Standard
Altro - Famiglia: M_Innesto - Filettato - MI - Classe 150: Standard; Famiglia e tipo: M_Innesto - Filettato - MI - Classe 150: Standard; ID tipo: M_Innesto - Filettato - MI - Classe 150: Standard; Raggio esterno banda: 0.0225 m; Raggio esterno raccordo: 0.0201 m; Tipo: M_Innesto - Filettato - MI - Classe 150: Standard
Dati identità - Contrassegno: Piano Uffici
Dimensioni - Diametro esterno banda: 0.045 m; Diametro esterno raccordo: 0.0402 m; Diametro interno raccordo: 0.0334 m; Diametro nominale: 0.025 m; Dimensione contrassegno: 0.01608 m; Dimensione massima: 0.025 m; Dimensione minima: 0.025 m; Dimensioni: ø25xø25; Larghezza banda: 0.0077 m; Larghezza isolamento banda: 0.0077 m; Lunghezza: 0.0424 m; Raggio nominale: 0.0125 m; Spessore metallo: 0.0034 m; Volume: 0.0000587592 m3
Fasi - Fase di creazione: Stato di Progetto
Grafica - Utilizza scala di annotazione: yes
Isolamento - Spessore isolamento: 0 m; Dimensione totale: ø25 mmxø25 mm
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco; Classificazione sistema: Protezione antincendio a secco; Nome sistema: Protezione antincendio a secco 291
Testo - Tipologia impianto: impianto a umido
Vincoli - Livello: Livello: Piano 3 (+12.85); Host: Livello : Piano 3 (+12.85); Offset: 3.5 m
Group: Protezione antincendio a secco 291

# IfcFlowFitting: Standard (475)
Type - Altro - Categoria: Raccordi tubazione; Nome famiglia: M_Raccordo a T - Filettato - MI - Classe 150; Nome tabella di ricerca: M_Tee - Threaded - MI - Class 150
Type - Dati identità - Commenti sul tipo: T; Descrizione: T; Nome del tipo: Standard; Numero OmniClass: 23.60.30.11.14; Titolo OmniClass: Pipework Fittings
Type - Meccanica - Metodo di perdita: Coefficiente K da tabella; Tabella di coefficienti K: Raccordo a T convergente/divergente/laterale
Pset_DistributionFlowElementCommon - Reference: Standard
Altro - Famiglia: M_Raccordo a T - Filettato - MI - Classe 150: Standard; Famiglia e tipo: M_Raccordo a T - Filettato - MI - Classe 150: Standard; ID tipo: M_Raccordo a T - Filettato - MI - Classe 150: Standard; Tipo: M_Raccordo a T - Filettato - MI - Classe 150: Standard
Fasi - Fase di creazione: Stato di Progetto
Grafica - Utilizza scala di annotazione: yes
Isolamento - Spessore isolamento: 0 m
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco
Name (M_Raccordo a T - Filettato - MI - Classe 150:Standard:...) | In | Angolo 1 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6270682 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6270912 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6270986 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6271771 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6271781 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6273655 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6273663 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6273746 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
