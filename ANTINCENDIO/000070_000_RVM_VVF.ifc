Properties of the parts of a building model (IFC2X3), part 55 of 58

# IfcFlowTerminal: VVF_tipo_VK520_upright (752)
Name (VVF_tipo_VK520_upright:VVF_tipo_VK520_upright:...) | In | Contrassegno | Nome sistema | Tipo di sistema | Tipologia impianto | Host | Livello | Offset (m) | Group
6279128 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279129 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279130 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279232 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279235 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279238 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279239 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279240 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279344 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279347 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279350 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279351 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279352 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279456 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279459 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279462 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279463 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279464 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279566 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279569 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279572 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279573 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279574 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279676 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279679 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279682 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279683 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279684 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279786 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279789 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279792 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279793 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279794 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279900 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279903 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279906 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279907 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279908 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280010 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280013 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280016 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280017 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280018 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280120 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280123 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280126 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280127 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280128 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280232 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280235 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280238 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280239 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3
6280340 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280343 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280346 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280454 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280457 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280460 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280461 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280462 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280568 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280571 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280574 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280575 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280576 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280680 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280683 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280686 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280687 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280688 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280832 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280835 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280838 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280839 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280840 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280944 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280947 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280950 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280951 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6280952 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281054 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281057 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281060 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281061 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281062 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281166 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281169 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281172 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281173 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281174 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281276 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281279 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281282 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281283 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281284 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281386 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281389 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281392 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281393 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281394 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281496 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281499 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281502 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281503 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281504 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281606 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281609 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281612 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281613 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281614 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281740 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281743 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281746 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281747 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281748 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281887 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281888 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281889 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281890 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281979 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281980 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281981 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6281982 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6283207 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.29786 | Protezione antincendio a secco 35
6283359 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6288346 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6288347 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6288348 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6288424 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6288425 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6288426 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6288912 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6288913 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6289247 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6289248 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6289298 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6289299 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6294646 | Piano 1 (+4.80) | Piano Primo |  |  | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3
6294649 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294652 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294653 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294654 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294655 | Piano 1 (+4.80) | Piano Primo |  |  | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3
6294656 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294657 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294722 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294723 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294724 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294725 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294778 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294779 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294780 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294781 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294834 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294835 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294836 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294837 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294888 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294891 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294892 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294951 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294952 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294953 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6294954 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295015 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 69 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 69
6295018 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 69 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 69
6295021 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 69 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 69
6295022 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 69 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 69
6295023 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 69 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 69
6295084 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295087 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295090 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295091 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295092 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295153 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295156 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295159 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295160 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295161 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295222 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295225 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295228 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295229 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295230 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295291 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295294 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295297 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295298 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295299 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295360 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295363 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295366 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295367 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295368 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295429 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295432 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295435 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295436 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295437 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295494 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295497 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295500 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295501 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295502 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295557 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295560 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295563 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295564 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295565 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295620 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295623 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295626 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295627 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295628 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295683 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295686 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295689 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295690 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295691 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295746 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295749 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295752 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295753 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295754 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295809 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295810 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295813 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295855 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295856 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295859 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295900 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295903 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295906 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295907 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295908 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295963 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295966 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295969 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295970 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6295971 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296026 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296029 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
