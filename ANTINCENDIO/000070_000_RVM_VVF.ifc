Properties of the parts of a building model (IFC2X3), part 41 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6297289 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 3.13549 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985045 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1216 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297299 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 3.7405 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.17511 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1217 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297305 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1218 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297307 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1219 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297309 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1220 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297323 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1221 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297371 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 820 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297391 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 0.760366 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238876 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 825 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297393 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.0905 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.525401 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 826 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297397 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 821 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297399 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 822 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297409 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 823 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297411 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 824 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297417 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 827 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297419 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 828 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297421 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 829 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297423 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 830 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297425 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 831 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297427 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 832 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297429 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 833 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297431 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 834 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297433 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.45935 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.869429 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3121 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6299044 | Piano 1 (+4.80) | Piano Primo | 0.01905 | 0.01905 | ø19 | 0.00665066 | ø19 mm |  | 0.000398025 |  |  | Protezione antincendio a secco 35 | 8.01026 | 0 |  | 809 | 0 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.21691 | 3.21026 | Protezione antincendio a secco 35
6300254 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.14922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0117197 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1882 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7242 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6300258 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1885 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6300264 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.458688 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0461124 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1879 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6300292 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.39388 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.266555 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1882 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6300294 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0110476 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138828 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1881 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6300543 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1906 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6300554 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1906 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6300560 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1909 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6300562 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1904 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6300565 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1905 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6300572 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1912 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6300580 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.502388 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.063132 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1902 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6300583 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1903 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302015 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.267265 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1682 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302049 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1685 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6302051 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1682 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6302063 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1681 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302068 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 2.57401 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.258768 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1680 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302583 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1835 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302589 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1835 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6302595 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1838 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6302597 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1833 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302600 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1834 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302607 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1841 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6302611 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.470452 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0591187 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1831 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302614 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1832 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302695 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1854 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302701 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1854 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6302707 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1857 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6302709 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.479016 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0481559 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1852 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302712 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1853 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6302761 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 1.43628 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.45122 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.65 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3336 | 0.0008 | impianto a umido | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7 | 3.7 | Protezione antincendio a secco 35
6302912 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.94932 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.992572 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1592 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6305924 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.14922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0117197 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 379 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7242 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6305928 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 382 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6305930 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.458776 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0461212 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1887 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6305938 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.39379 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.266548 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 379 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6305940 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0110257 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138553 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 378 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306046 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.284146 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 53 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306053 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 53 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306059 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1874 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306061 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.575 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.359398 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1871 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306064 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1872 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306071 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1877 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306075 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.502388 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.063132 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1869 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306078 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1870 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306141 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 4.04534 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.0167 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306192 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1893 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306199 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1893 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306205 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1896 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306207 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1891 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306210 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1892 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306217 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1899 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306221 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.502388 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.063132 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1890 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306224 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 385 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306259 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1919 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306266 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1919 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306272 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1922 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306274 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1917 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306277 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1918 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306284 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1925 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306288 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.502388 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.063132 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1915 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306291 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1916 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306326 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1932 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306333 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1932 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306339 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 433 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306341 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1930 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306344 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1931 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306351 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1937 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306355 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.502388 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.063132 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1928 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306358 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1929 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306393 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 444 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306400 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 444 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306406 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 447 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306408 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 442 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306411 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 443 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306418 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1943 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306422 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1940 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306425 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1941 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306462 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1951 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306469 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1951 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306475 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1954 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306477 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1949 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306480 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1950 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306487 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1957 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306491 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1945 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306494 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1948 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306529 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1965 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306536 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1965 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306542 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1968 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306544 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1963 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306547 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1964 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
