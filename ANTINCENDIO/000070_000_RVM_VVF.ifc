Properties of the parts of a building model (IFC2X3), part 23 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6318488 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 19 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 19
6318493 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 29 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 29
6318500 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 29 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 29
6318504 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6318506 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6318510 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6318572 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 25 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 25
6318576 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 27 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6318578 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6318590 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 22 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 22
6318594 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 22 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 22 | Meccanico - Flusso - Caduta pressione: 0 Pa
6318596 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 30 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 30
6318601 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 25 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 25
6318607 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 25 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 25
6318612 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 39 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 39
6318619 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 39 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 39
6318623 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6318625 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6318629 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6318691 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 31 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 31
6318695 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 33 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6318697 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6318709 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 28 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 28
6318713 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 28 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 28 | Meccanico - Flusso - Caduta pressione: 0 Pa
6318715 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 41 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 41
6318720 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 31 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 31
6318726 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 31 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 31
6318731 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 46 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 46
6318738 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 46 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 46
6318742 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6318744 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6318748 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6318806 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 42 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 42
6318810 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 44 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6318812 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6318824 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 34 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 34
6318828 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 34 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 34 | Meccanico - Flusso - Caduta pressione: 0 Pa
6318830 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 47 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 47
6318835 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 42 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 42
6318841 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 42 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 42
6318846 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 52 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 52
6318853 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 52 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 52
6318857 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6318859 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6318863 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6318933 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 48 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 48
6318937 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 50 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6318939 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6318951 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 45 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 45
6318955 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 45 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 45 | Meccanico - Flusso - Caduta pressione: 0 Pa
6318962 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 48 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 48
6318968 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 48 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 48
6318973 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 58 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 58
6318980 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 58 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 58
6318984 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6318986 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6318990 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6319086 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 54 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 54
6319088 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 51 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 51
6319094 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 51 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 51
6319111 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 54 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 54
6319117 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 54 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 54
6319121 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 51 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 51
6319123 | Piano 3 (+12.85) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 51 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4032 | Protezione antincendio a secco 51
6319131 | Piano 3 (+12.85) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6319133 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6319135 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6319138 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 65 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 65
6319142 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 65 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5493 | Protezione antincendio a secco 65 | Meccanico - Flusso - Caduta pressione: 0 Pa
6319207 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 56 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 56
6319209 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 55 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 55
6319215 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 55 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 55
6319232 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 56 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 56
6319238 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 56 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 56
6319242 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 55 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 55
6319244 | Piano 3 (+12.85) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 55 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4032 | Protezione antincendio a secco 55
6319252 | Piano 3 (+12.85) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6319254 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6319256 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6319259 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 72 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 72
6319263 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 72 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5493 | Protezione antincendio a secco 72 | Meccanico - Flusso - Caduta pressione: 0 Pa
6319324 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 61 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 61
6319326 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 60 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 60
6319332 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 60 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 60
6319349 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 61 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 61
6319355 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 61 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 61
6319359 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 60 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 60
6319361 | Piano 3 (+12.85) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 60 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4032 | Protezione antincendio a secco 60
6319369 | Piano 3 (+12.85) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6319371 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6319373 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6319376 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 78 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 78
6319380 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 78 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5493 | Protezione antincendio a secco 78 | Meccanico - Flusso - Caduta pressione: 0 Pa
6319443 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 66 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 66
6319445 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 64 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 64
6319451 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 64 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 64
6319468 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 66 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 66
6319474 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 66 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 66
6319478 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 64 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 64
6319480 | Piano 3 (+12.85) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 64 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4032 | Protezione antincendio a secco 64
6319488 | Piano 3 (+12.85) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
