Properties of the parts of a building model (IFC2X3), part 46 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6319829 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2197 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319831 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 86 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 86
6319835 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.45941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.309059 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2187 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319839 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 94 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6319842 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2192 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319845 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2200 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6319848 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 86 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 86 | Dati identità - Commenti: Stacco
6319853 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 86 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 86 | Dati identità - Commenti: Stacco
6319866 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2195 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319868 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2194 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6319879 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 103 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 103 | Dati identità - Commenti: Stacco
6319883 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 105 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6320321 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 92 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 92
6320327 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2181 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320329 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 92 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 92
6320333 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.5234 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0657724 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3351 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320337 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 100 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6320340 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2176 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320343 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2184 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320346 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 92 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 92 | Dati identità - Commenti: Stacco
6320351 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 92 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 92 | Dati identità - Commenti: Stacco
6320364 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2179 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320366 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2178 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320377 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 109 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 109 | Dati identità - Commenti: Stacco
6320381 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 111 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6320438 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 98 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 98
6320444 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2155 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320446 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 98 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 98
6320450 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.45941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.309059 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2145 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320454 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 106 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6320457 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2150 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320460 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2158 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320463 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 98 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 98 | Dati identità - Commenti: Stacco
6320468 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 98 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 98 | Dati identità - Commenti: Stacco
6320481 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2153 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320483 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2152 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320494 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 115 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 115 | Dati identità - Commenti: Stacco
6320498 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 117 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6320557 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 104 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 104
6320563 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2129 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320565 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 104 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 104
6320569 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.45941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.309059 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2119 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320573 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 112 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6320576 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2124 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320579 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2132 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320582 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 104 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 104 | Dati identità - Commenti: Stacco
6320587 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 104 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 104 | Dati identità - Commenti: Stacco
6320600 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2127 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320602 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2126 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320613 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 121 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 121 | Dati identità - Commenti: Stacco
6320617 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 123 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6320674 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 110 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 110
6320680 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2110 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320682 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 110 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 110
6320686 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.5234 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0657724 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2100 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320690 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 118 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6320693 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2105 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320696 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2113 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320699 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 110 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 110 | Dati identità - Commenti: Stacco
6320704 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 110 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 110 | Dati identità - Commenti: Stacco
6320717 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2108 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320719 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2107 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320730 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 127 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 127 | Dati identità - Commenti: Stacco
6320734 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 129 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6320793 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 116 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 116
6320799 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2084 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320801 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 116 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 116
6320805 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.45941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.309059 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2074 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320809 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 124 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6320812 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2079 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320815 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2087 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320818 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 116 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 116 | Dati identità - Commenti: Stacco
6320823 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 116 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 116 | Dati identità - Commenti: Stacco
6320836 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2082 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320838 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2081 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320849 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 134 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 134 | Dati identità - Commenti: Stacco
6320853 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 136 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6320908 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.61786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.205606 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 122 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 122
6320914 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2068 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320916 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 122 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 122
6320920 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.45941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.309059 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2061 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320924 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 130 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6320927 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2064 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320930 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2071 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6320933 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 122 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 122 | Dati identità - Commenti: Stacco
6320938 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 122 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 122 | Dati identità - Commenti: Stacco
6320951 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.60448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.261831 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2066 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320953 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 18 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6320964 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 141 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 141 | Dati identità - Commenti: Stacco
6320968 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 143 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6321027 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.06786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240949 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 128 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 128
6321033 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2385 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321035 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 128 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 128
6321039 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 1.34941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.169572 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2375 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321043 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 137 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6321046 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2380 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321049 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2388 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321052 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 128 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 128 | Dati identità - Commenti: Stacco
6321057 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 128 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 128 | Dati identità - Commenti: Stacco
6321070 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.05448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.30707 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2383 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321072 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2382 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321083 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 147 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 147 | Dati identità - Commenti: Stacco
6321087 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 149 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6321408 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.06786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240949 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 95 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 95
6321414 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2401 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321416 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 95 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 95
6321420 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 1.34941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.169572 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2391 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321424 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 113 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6321427 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2396 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321430 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2404 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321433 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 95 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 95 | Dati identità - Commenti: Stacco
6321438 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 95 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 95 | Dati identità - Commenti: Stacco
6321451 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.05448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.30707 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2399 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321453 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2398 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321462 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 139 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 139 | Dati identità - Commenti: Stacco
6321466 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 142 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
