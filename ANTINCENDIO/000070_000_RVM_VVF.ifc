Properties of the parts of a building model (IFC2X3), part 27 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6323187 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 213 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 213
6323191 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 213 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5493 | Protezione antincendio a secco 213 | Meccanico - Flusso - Caduta pressione: 0 Pa
6323195 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6323252 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 202 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 202
6323254 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6323260 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 35
6323277 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 202 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 202
6323283 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 202 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 202
6323287 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6323289 | Piano 3 (+12.85) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4032 | Protezione antincendio a secco 35
6323297 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6323299 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6323302 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 218 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 218
6323306 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 218 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5493 | Protezione antincendio a secco 218 | Meccanico - Flusso - Caduta pressione: 0 Pa
6323310 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6323377 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 207 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 207
6323379 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 206 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 206
6323385 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 206 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 206
6323402 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 207 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 207
6323408 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 207 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 207
6323412 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 206 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 206
6323414 | Piano 3 (+12.85) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 206 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4032 | Protezione antincendio a secco 206
6323422 | Piano 3 (+12.85) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6323424 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6323426 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6323429 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 224 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 224
6323433 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 224 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5493 | Protezione antincendio a secco 224 | Meccanico - Flusso - Caduta pressione: 0 Pa
6323509 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6323518 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 35
6323632 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6323637 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 35
6323690 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 219 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 219
6323694 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 222 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6323696 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6323708 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 217 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 217
6323712 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 217 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 217 | Meccanico - Flusso - Caduta pressione: 0 Pa
6323714 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 225 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 225
6323719 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 219 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 219
6323725 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 219 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 219
6323730 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 231 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 231
6323737 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 231 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 231
6323741 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6323743 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6323747 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6323827 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 227 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 227
6323831 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 229 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6323833 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6323845 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 223 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 223
6323849 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 223 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 223 | Meccanico - Flusso - Caduta pressione: 0 Pa
6323851 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 232 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 232
6323856 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 227 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 227
6323862 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 227 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 227
6323867 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 237 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 237
6323874 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 237 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 237
6323878 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6323880 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6323884 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6323942 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 233 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 233
6323946 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 235 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6323948 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6323960 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 230 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 230
6323964 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 230 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 230 | Meccanico - Flusso - Caduta pressione: 0 Pa
6323966 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 238 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 238
6323971 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 233 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 233
6323977 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 233 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 233
6323982 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 243 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 243
6323989 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 243 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 243
6323993 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6323995 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6323999 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6324057 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 239 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 239
6324061 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 241 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6324063 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6324075 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 236 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 236
6324079 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 236 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 236 | Meccanico - Flusso - Caduta pressione: 0 Pa
6324081 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 244 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 244
6324086 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 239 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 239
6324092 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 239 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 239
6324097 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 249 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 249
6324104 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 249 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 249
6324108 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6324110 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6324114 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6324172 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 245 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 245
6324176 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 247 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6324178 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6324190 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 242 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 242
6324194 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 242 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 242 | Meccanico - Flusso - Caduta pressione: 0 Pa
6324196 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 250 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 250
6324201 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 245 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 245
6324207 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 245 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 245
6324212 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 255 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 255
6324219 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 255 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 255
6324223 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6324225 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6324229 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6324287 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 251 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 251
6324291 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 253 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6324293 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6324305 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 248 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 248
