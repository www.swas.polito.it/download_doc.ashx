Properties of the parts of a building model (IFC2X3), part 1 of 58

# File
Description: ViewDefinition [CoordinationView]
File name: 000070_000
Time: 2016-04-06T17:03:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 06 17:03:18 2016 * Host: Doc * Database: C:\Users\Dario\AppData\Local\Temp\{E60C6155-5EAC-4CC0-AEEB-BAB3FE71C83F}\ifc * Database version: 5507 * Database creation date: Wed Apr 06 17:02:10 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 06 17:02:10 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 06 17:02:10 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 000070_000
LongName: SOPRAELEVAZIONE PARCHEGGIO PLURIPIANO - REALIZZAZIONE LABORATORI E UFFICI; Phase: ESECUTIVO

# IfcSite, Default
RefLatitude: 41, 53, 43, 677062; RefLongitude: 12, 28, 56, 368560; RefElevation: 250.6 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: 18/12/2015; Indirizzo del progetto: C.so Castelfidardo 36 - 10129 Torino; Nome del cliente: POLITECNICO DI TORINO; Nome del progetto: SOPRAELEVAZIONE PARCHEGGIO PLURIPIANO - REALIZZAZIONE LABORATORI E UFFICI; Numero del progetto: 000070_000; Stato del progetto: ESECUTIVO
Dati identità - Autore: ENERGYMEP; Nome edificio: NUOVO PIANO UFFICI

# IfcBuilding, NUOVO PIANO UFFICI
LongName: NUOVO PIANO UFFICI
Pset_BuildingCommon - NumberOfStoreys: 6
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: 18/12/2015; Indirizzo del progetto: C.so Castelfidardo 36 - 10129 Torino; Nome del cliente: POLITECNICO DI TORINO; Nome del progetto: SOPRAELEVAZIONE PARCHEGGIO PLURIPIANO - REALIZZAZIONE LABORATORI E UFFICI; Numero del progetto: 000070_000; Stato del progetto: ESECUTIVO
Dati identità - Autore: ENERGYMEP; Nome edificio: NUOVO PIANO UFFICI

# IfcBuildingStorey (6)
In: NUOVO PIANO UFFICI
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello; Nome famiglia: Livello
Dati identità - Piano edificio: yes; Strutturale: no; Nome del tipo: Livello
Dimensioni - Altezza di calcolo: 0 m
Grafica - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Vincoli - Base quota altimetrica: Punto base progetto
Name | LongName = Nome | Elevation (m) = Quota altimetrica (m)
PR_VVF_0200_SPR_Sezione su scala | PR_VVF_0200_SPR_Sezione su scala | 0
Piano 1 (+4.80) | Piano 1 (+4.80) | 4.8
Piano 2 (+8.61) | Piano 2 (+8.61) | 8.61
Piano 3 (+12.85) | Piano 3 (+12.85) | 12.85
Piano 3 contr (+15.95) | Piano 3 contr (+15.95) | 15.95
Piano 3 contr (+16.01) luci | Piano 3 contr (+16.01) luci | 16.0069

# IfcBuildingElementProxy: A secco, VVF_Attrezz_mecc_Stazione di allarme:A secco:6412857
In: PR_VVF_0200_SPR_Sezione su scala
Pset_BuildingElementProxyCommon - Reference: A secco
Altro - Categoria: Attrezzatura meccanica; Famiglia: VVF_Attrezz_mecc_Stazione di allarme: A secco; Famiglia e tipo: VVF_Attrezz_mecc_Stazione di allarme: A secco; ID tipo: VVF_Attrezz_mecc_Stazione di allarme: A secco; Tipo: VVF_Attrezz_mecc_Stazione di allarme: A secco; Nome famiglia: VVF_Attrezz_mecc_Stazione di allarme; Raggio esterno 2: 0.05635 m; Raggio flangia 2: 0.0754 m; Raggio girante: 0.089 m; Raggio motore: 0.0685 m
Dati identità - Commenti: Stazione di impianto a secco; Contrassegno: GF16; Nome del tipo: A secco; Numero OmniClass: 23.60.30.21; Titolo OmniClass: Pumps
Dimensioni - Area: 0.281846 m2; Volume: 0.0166182 m3; Altezza 1: 0.16 m; Altezza 2: 0.268 m; Altezza motore: 0.306 m; C1 Offset 1: 0.254 m; C2 Offset 1: 0.254 m; Diametro 1: 0.109 m; Diametro aspirazione: 0.1 m; Diametro espulsione: 0.1 m; Diametro esterno 1: 0.1127 m; Diametro esterno 2: 0.1127 m; Diametro flangia 1: 0.1635 m; Diametro flangia 2: 0.1508 m; Diametro girante: 0.178 m; Diametro motore: 0.137 m; Raggio_1: 0.0545 m; Raggio aspirazione: 0.05 m; Raggio espulsione: 0.05 m
Fasi - Fase di creazione: Stato di Progetto
Meccanica - Classificazione sistema: Protezione antincendio a secco,Alimentazione; Nome sistema: Protezione antincendio a secco 35; RPM: 1760
Testo - Tipologia impianto: impianto a secco
Vincoli - Livello: Livello: PR_VVF_0200_SPR_Sezione su scala; Host: Livello : PR_VVF_0200_SPR_Sezione su scala; Offset: 0.492102 m
Elettrico - Classificazione carico: Apparecchiatura - Unità abitativa; Numero di poli: 3; Voltaggio: 460 V
Elettrico - Carichi - Carico apparente: 1880 W

# IfcBuildingElementProxy: A umido, VVF_Attrezz_mecc_Stazione di allarme:A umido:6413774
In: PR_VVF_0200_SPR_Sezione su scala
Pset_BuildingElementProxyCommon - Reference: A umido
Altro - Categoria: Attrezzatura meccanica; Famiglia: VVF_Attrezz_mecc_Stazione di allarme: A umido; Famiglia e tipo: VVF_Attrezz_mecc_Stazione di allarme: A umido; ID tipo: VVF_Attrezz_mecc_Stazione di allarme: A umido; Tipo: VVF_Attrezz_mecc_Stazione di allarme: A umido; Nome famiglia: VVF_Attrezz_mecc_Stazione di allarme; Raggio esterno 2: 0.05635 m; Raggio flangia 2: 0.0754 m; Raggio girante: 0.089 m; Raggio motore: 0.0685 m
Dati identità - Commenti: Stazione di impianto a umido; Contrassegno: GF17; Nome del tipo: A umido; Numero OmniClass: 23.60.30.21; Titolo OmniClass: Pumps
Dimensioni - Area: 0.281846 m2; Volume: 0.0166182 m3; Altezza 1: 0.16 m; Altezza 2: 0.268 m; Altezza motore: 0.306 m; C1 Offset 1: 0.254 m; C2 Offset 1: 0.254 m; Diametro 1: 0.109 m; Diametro aspirazione: 0.1 m; Diametro espulsione: 0.1 m; Diametro esterno 1: 0.1127 m; Diametro esterno 2: 0.1127 m; Diametro flangia 1: 0.1635 m; Diametro flangia 2: 0.1508 m; Diametro girante: 0.178 m; Diametro motore: 0.137 m; Raggio_1: 0.0545 m; Raggio aspirazione: 0.05 m; Raggio espulsione: 0.05 m
Fasi - Fase di creazione: Stato di Progetto
Meccanica - Classificazione sistema: Protezione antincendio a secco,Alimentazione; Nome sistema: Protezione antincendio a secco 35; RPM: 1760
Testo - Tipologia impianto: impianto a umido
Vincoli - Livello: Livello: PR_VVF_0200_SPR_Sezione su scala; Host: Livello : PR_VVF_0200_SPR_Sezione su scala; Offset: 0.492102 m
Elettrico - Classificazione carico: Apparecchiatura - Unità abitativa; Numero di poli: 3; Voltaggio: 460 V
Elettrico - Carichi - Carico apparente: 1880 W

# IfcBuildingElementProxy: Blindosbarra modulo 3m (152)
In: Piano 3 (+12.85)
Pset_BuildingElementProxyCommon - Reference: Blindosbarra modulo 3m
Pset_ManufacturerTypeInformation - Manufacturer: ing. Damiano Zurlo
Altro - Categoria: Attrezzatura elettrica; Famiglia: MEP2015_Blindo 3m: Blindosbarra modulo 3m; Famiglia e tipo: MEP2015_Blindo 3m: Blindosbarra modulo 3m; ID tipo: MEP2015_Blindo 3m: Blindosbarra modulo 3m; Tipo: MEP2015_Blindo 3m: Blindosbarra modulo 3m; Nome famiglia: MEP2015_Blindo 3m
Dimensioni - Area: 0.316369 m2; Volume: 0.00684555 m3; b: 1.27461 m; h: 0.918114 m; p: 1.3382 m
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Fattore di richiesta totale: 1; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : Piano 3 (+12.85); Livello: Livello: Piano 3 (+12.85); Offset: -0.25 m; Sposta con l'oggetto più vicino: no
Dati identità - Commenti sul tipo: Blindosbarra di alimentazione; Descrizione: famiglia generica; Modello: MEP2015-F00; Nome del tipo: Blindosbarra modulo 3m; Numero OmniClass: 23.80.30.11.17; Produttore: ing. Damiano Zurlo; Titolo OmniClass: Distribution Boards and Control Panels; URL: www.energymep.it
Name (MEP2015_Blindo 3m:Blindosbarra modulo 3m:...) | Numero Circuito XY | Commenti | Contrassegno | Posizione
1475574 | 25 | BF6-EN | 22 | UFFICI "OPEN SPACE" 3.37
1475575 | 24 | BF5-EN | 23 | UFFICI "OPEN SPACE" 3.37
1475585 | 20 | BF1-EN | 24 | UFFICI "OPEN SPACE" 3.38
1475700 | 21 | BF2-EN | 35 | UFFICI "OPEN SPACE" 3.38
1478993 | 26 | BF7-EN | 68 | SALA RIUNIONI 3.25
1479936 | 25 | BF6-EN | 71 | UFFICI "OPEN SPACE" 3.37
1479937 | 24 | BF5-EN | 25 | UFFICI "OPEN SPACE" 3.37
1479966 | 25 | BF6-EN | 73 | UFFICI "OPEN SPACE" 3.37
1479967 | 24 | BF5-EN | 26 | UFFICI "OPEN SPACE" 3.37
1479970 | 25 | BF6-EN | 75 | UFFICI "OPEN SPACE" 3.37
1479971 | 24 | BF5-EN | 27 | UFFICI "OPEN SPACE" 3.37
1479974 | 25 | BF6-EN | 77 | UFFICI "OPEN SPACE" 3.37
1479975 | 24 | BF5-EN | 28 | UFFICI "OPEN SPACE" 3.37
1479978 | 25 | BF6-EN | 79 | UFFICI "OPEN SPACE" 3.37
1479979 | 24 | BF5-EN | 29 | UFFICI "OPEN SPACE" 3.37
1479982 | 25 | BF6-EN | 81 | UFFICI "OPEN SPACE" 3.37
1479983 | 24 | BF5-EN | 30 | UFFICI "OPEN SPACE" 3.37
1480006 | 26 | BF7-EN | 83 | SALA RIUNIONI 3.26
1480043 | 26 | BF7-EN | 84 | SALA RIUNIONI 3.26
1480046 | 26 | BF7-EN | 85 | SALA RIUNIONI 3.26
1480049 | 26 | BF7-EN | 86 | SALA RIUNIONI 3.27
1480052 | 26 | BF7-EN | 87 | SALA RIUNIONI 3.27
1480055 | 26 | BF7-EN | 88 | SALA RIUNIONI 3.28
1480257 | 22 | BF3-EN | 47 | UFFICI "OPEN SPACE" 3.38
2797876 | 48 | BF3-EC | 40 | UFFICI "OPEN SPACE" 3.37
2797988 | 46 | BF1-EC | 655 | UFFICI "OPEN SPACE" 3.38
2798059 | 47 | BF2-EC | 660 | UFFICI "OPEN SPACE" 3.38
2798514 | 49 | BF4-EC | 669 | SALA RIUNIONI 3.25
2798545 | 49 | BF4-EC | 670 | SALA RIUNIONI 3.26
2798562 | 49 | BF4-EC | 671 | SALA RIUNIONI 3.26
2798565 | 49 | BF4-EC | 672 | SALA RIUNIONI 3.26
2798568 | 49 | BF4-EC | 673 | SALA RIUNIONI 3.27
2798571 | 49 | BF4-EC | 674 | SALA RIUNIONI 3.27
2798607 | 27 | BF8-EN | 676 | SALA RIUNIONI 3.25
2798619 | 27 | BF8-EN | 677 | SALA RIUNIONI 3.26
2798631 | 27 | BF8-EN | 678 | SALA RIUNIONI 3.26
2798634 | 27 | BF8-EN | 679 | SALA RIUNIONI 3.26
2798637 | 27 | BF8-EN | 680 | SALA RIUNIONI 3.27
2798640 | 27 | BF8-EN | 681 | SALA RIUNIONI 3.27
2798643 | 27 | BF8-EN | 682 | SALA RIUNIONI 3.28
4429707 | 48 | BF3-EC | 41 | UFFICI "OPEN SPACE" 3.37
4429748 | 48 | BF3-EC | 42 | UFFICI "OPEN SPACE" 3.37
4429751 | 48 | BF3-EC | 43 | UFFICI "OPEN SPACE" 3.37
4429754 | 48 | BF3-EC | 44 | UFFICI "OPEN SPACE" 3.37
4429757 | 48 | BF3-EC | 45 | UFFICI "OPEN SPACE" 3.37
4429760 | 48 | BF3-EC | 46 | UFFICI "OPEN SPACE" 3.37
4430655 | 20 | BF1-EN | 61 | UFFICI "OPEN SPACE" 3.39
4430656 | 21 | BF2-EN | 62 | UFFICI "OPEN SPACE" 3.39
4430657 | 46 | BF1-EC | 63 | UFFICI "OPEN SPACE" 3.39
4431002 | 20 | BF1-EN | 64 | UFFICI "OPEN SPACE" 3.39
4431003 | 21 | BF2-EN | 65 | UFFICI "OPEN SPACE" 3.39
4431004 | 46 | BF1-EC | 66 | UFFICI "OPEN SPACE" 3.39
4431033 | 20 | BF1-EN | 67 | UFFICI "OPEN SPACE" 3.39
4431034 | 21 | BF2-EN | 69 | UFFICI "OPEN SPACE" 3.39
4431035 | 46 | BF1-EC | 70 | UFFICI "OPEN SPACE" 3.39
4431038 | 20 | BF1-EN | 72 | UFFICI "OPEN SPACE" 3.39
4431039 | 21 | BF2-EN | 74 | UFFICI "OPEN SPACE" 3.39
4431040 | 46 | BF1-EC | 76 | UFFICI "OPEN SPACE" 3.39
4431043 | 20 | BF1-EN | 78 | UFFICI "OPEN SPACE" 3.39
4431044 | 21 | BF2-EN | 90 | UFFICI "OPEN SPACE" 3.39
4431045 | 46 | BF1-EC | 107 | UFFICI "OPEN SPACE" 3.39
4431425 | 20 | BF1-EN | 438 | UFFICI "OPEN SPACE" 3.39
4431426 | 21 | BF2-EN | 439 | UFFICI "OPEN SPACE" 3.39
4431427 | 46 | BF1-EC | 440 | UFFICI "OPEN SPACE" 3.39
4431430 | 20 | BF1-EN | 441 | UFFICI "OPEN SPACE" 3.39
4431431 | 21 | BF2-EN | 442 | UFFICI "OPEN SPACE" 3.39
4431432 | 46 | BF1-EC | 443 | UFFICI "OPEN SPACE" 3.39
4431435 | 20 | BF1-EN | 444 | UFFICI "OPEN SPACE" 3.39
4431436 | 21 | BF2-EN | 445 | UFFICI "OPEN SPACE" 3.39
4431437 | 46 | BF1-EC | 446 | UFFICI "OPEN SPACE" 3.39
4431440 | 20 | BF1-EN | 447 | UFFICI "OPEN SPACE" 3.39
4431441 | 21 | BF2-EN | 448 | UFFICI "OPEN SPACE" 3.39
4431442 | 46 | BF1-EC | 449 | UFFICI "OPEN SPACE" 3.39
4431464 | 22 | BF3-EN | 453 | SALA RIUNIONI 3.24
4431465 | 47 | BF2-EC | 455 | SALA RIUNIONI 3.24
4431466 | 23 | BF4-EN | 456 | SALA RIUNIONI 3.24
4431600 | 22 | BF3-EN | 457 | SALA RIUNIONI 3.29
4431601 | 47 | BF2-EC | 458 | SALA RIUNIONI 3.29
4431602 | 23 | BF4-EN | 459 | SALA RIUNIONI 3.29
4431619 | 22 | BF3-EN | 460 | SALA RIUNIONI 3.29
4431620 | 47 | BF2-EC | 461 | SALA RIUNIONI 3.29
4431621 | 23 | BF4-EN | 462 | SALA RIUNIONI 3.29
4431645 | 24 | BF5-EN | 469 | UFFICI "OPEN SPACE" 3.40
4431646 | 48 | BF3-EC | 470 | UFFICI "OPEN SPACE" 3.40
4431647 | 25 | BF6-EN | 471 | UFFICI "OPEN SPACE" 3.40
4431760 | 24 | BF5-EN | 472 | UFFICI "OPEN SPACE" 3.40
4431761 | 48 | BF3-EC | 473 | UFFICI "OPEN SPACE" 3.40
4431762 | 25 | BF6-EN | 474 | UFFICI "OPEN SPACE" 3.40
4431792 | 24 | BF5-EN | 475 | UFFICI "OPEN SPACE" 3.40
4431793 | 48 | BF3-EC | 476 | UFFICI "OPEN SPACE" 3.40
4431794 | 25 | BF6-EN | 477 | UFFICI "OPEN SPACE" 3.40
4431797 | 24 | BF5-EN | 478 | UFFICI "OPEN SPACE" 3.40
4431798 | 48 | BF3-EC | 479 | UFFICI "OPEN SPACE" 3.40
4431799 | 25 | BF6-EN | 486 | UFFICI "OPEN SPACE" 3.40
4431802 | 24 | BF5-EN | 487 | UFFICI "OPEN SPACE" 3.40
4431803 | 48 | BF3-EC | 488 | UFFICI "OPEN SPACE" 3.40
4431804 | 25 | BF6-EN | 493 | UFFICI "OPEN SPACE" 3.40
4431807 | 24 | BF5-EN | 494 | UFFICI "OPEN SPACE" 3.40
4431808 | 48 | BF3-EC | 495 | UFFICI "OPEN SPACE" 3.40
4431809 | 25 | BF6-EN | 496 | UFFICI "OPEN SPACE" 3.40
4431831 | 26 | BF7-EN | 637 | UFFICI "OPEN SPACE" 3.40
4431832 | 49 | BF4-EC | 638 | UFFICI "OPEN SPACE" 3.40
4431833 | 27 | BF8-EN | 639 | UFFICI "OPEN SPACE" 3.40
4431902 | 26 | BF7-EN | 640 | UFFICI "OPEN SPACE" 3.40
4431903 | 49 | BF4-EC | 641 | UFFICI "OPEN SPACE" 3.40
4431904 | 27 | BF8-EN | 642 | UFFICI "OPEN SPACE" 3.40
4431928 | 26 | BF7-EN | 643 | UFFICI "OPEN SPACE" 3.40
4431929 | 49 | BF4-EC | 644 | UFFICI "OPEN SPACE" 3.40
4431930 | 27 | BF8-EN | 645 | UFFICI "OPEN SPACE" 3.40
4431933 | 26 | BF7-EN | 646 | UFFICI "OPEN SPACE" 3.40
4431934 | 49 | BF4-EC | 647 | UFFICI "OPEN SPACE" 3.40
4431935 | 27 | BF8-EN | 648 | UFFICI "OPEN SPACE" 3.40
4431938 | 26 | BF7-EN | 649 | UFFICI "OPEN SPACE" 3.40
4431939 | 49 | BF4-EC | 651 | UFFICI "OPEN SPACE" 3.40
4431940 | 27 | BF8-EN | 675 | UFFICI "OPEN SPACE" 3.40
4456862 | 23 | BF4-EN | 466 | UFFICI "OPEN SPACE" 3.38
4457213 | 20 | BF1-EN | 757 | UFFICI "OPEN SPACE" 3.38
4457214 | 21 | BF2-EN | 758 | UFFICI "OPEN SPACE" 3.38
4457215 | 46 | BF1-EC | 759 | UFFICI "OPEN SPACE" 3.38
4457228 | 20 | BF1-EN | 760 | UFFICI "OPEN SPACE" 3.38
4457229 | 21 | BF2-EN | 761 | UFFICI "OPEN SPACE" 3.38
4457230 | 46 | BF1-EC | 762 | UFFICI "OPEN SPACE" 3.38
4457233 | 20 | BF1-EN | 763 | UFFICI "OPEN SPACE" 3.38
4457234 | 21 | BF2-EN | 764 | UFFICI "OPEN SPACE" 3.38
4457235 | 46 | BF1-EC | 765 | UFFICI "OPEN SPACE" 3.38
4457238 | 20 | BF1-EN | 766 | UFFICI "OPEN SPACE" 3.38
4457239 | 21 | BF2-EN | 767 | UFFICI "OPEN SPACE" 3.38
4457240 | 46 | BF1-EC | 768 | UFFICI "OPEN SPACE" 3.38
4457312 | 22 | BF3-EN | 769 | UFFICI "OPEN SPACE" 3.38
4457313 | 47 | BF2-EC | 770 | UFFICI "OPEN SPACE" 3.38
4457314 | 23 | BF4-EN | 771 | UFFICI "OPEN SPACE" 3.38
4457332 | 22 | BF3-EN | 772 | UFFICI "OPEN SPACE" 3.38
4457333 | 47 | BF2-EC | 773 | UFFICI "OPEN SPACE" 3.38
4457334 | 23 | BF4-EN | 774 | UFFICI "OPEN SPACE" 3.38
4457337 | 22 | BF3-EN | 775 | UFFICI "OPEN SPACE" 3.38
4457338 | 47 | BF2-EC | 776 | UFFICI "OPEN SPACE" 3.38
4457339 | 23 | BF4-EN | 777 | UFFICI "OPEN SPACE" 3.38
5368964 | 46 | BF1-EC | 504 | CORRIDOIO "OPEN SPACE" 3.10
5371558 | 47 | BF2-EC | 614 | UFFICI "OPEN SPACE" 3.38
5371564 | 47 | BF2-EC | 636 | ACCOGLIENZA 3.1
5371598 | 22 | BF3-EN | 650 | UFFICI "OPEN SPACE" 3.38
5371599 | 23 | BF4-EN | 656 | UFFICI "OPEN SPACE" 3.38
5371605 | 22 | BF3-EN | 657 | ACCOGLIENZA 3.1
5371606 | 23 | BF4-EN | 693 | ACCOGLIENZA 3.1
5371762 | 49 | BF4-EC | 700 | SALA RIUNIONI 3.28
5374366 | 49 | BF4-EC | 711 | UFFICI "OPEN SPACE" 3.40
5374509 | 20 | BF1-EN | 715 | ACCOGLIENZA 3.3
5374510 | 21 | BF2-EN | 716 | ACCOGLIENZA 3.3
5374511 | 46 | BF1-EC | 718 | ACCOGLIENZA 3.3
5374522 | 20 | BF1-EN | 719 | ACCOGLIENZA 3.3
5374523 | 21 | BF2-EN | 724 | ACCOGLIENZA 3.3
5374524 | 46 | BF1-EC | 725 | ACCOGLIENZA 3.3

# IfcDistributionControlElement: Controsoffitto (56)
In: Piano 3 contr (+15.95)
Type - Altro - Categoria: Dispositivi allarme incendio; VVF_Visibilità_ARea_Influenza: yes; Nome famiglia: VVF_Rivelatore_fumo_controsoffitto
Type - Dati identità - Modello: CONTROSOFFITTO; Nome del tipo: Controsoffitto; Numero OmniClass: 23.85.30.21.11.11.11; Titolo OmniClass: Smoke Detectors
Type - Dimensioni - Estremità - raggio piccolo: 0.038 m; Profondità base: 0.051 m; Profondità estremità: 0.038 m; Raggio base: 0.1 m; Raggio estremità: 0.051 m; VVF_Area_Influenza: 4.5 m
Type - Vincoli - Prospetto di default: 1.2 m
Altro - Livello abaco: Livello: Piano 3 (+12.85); Famiglia: VVF_Rivelatore_fumo_controsoffitto: Controsoffitto; Famiglia e tipo: VVF_Rivelatore_fumo_controsoffitto: Controsoffitto; ID tipo: VVF_Rivelatore_fumo_controsoffitto: Controsoffitto; Tipo: VVF_Rivelatore_fumo_controsoffitto: Controsoffitto
Dimensioni - Volume: 0.00204276 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Livello: Livello: Piano 3 (+12.85); Host: Modello di Revit collegato : 000070_000_RVM_ARC_ESE.rvt; Offset: 3.05 m; Prospetto: 3.05 m
Name (VVF_Rivelatore_fumo_controsoffitto:Controsoffitto:...) | Contrassegno
6347701 | 57
6349866 | 59
6349878 | 60
6349888 | 61
6349900 | 62
6351072 | 63
6351082 | 64
6353231 | 66
6353245 | 67
6353257 | 68
6353269 | 69
6353297 | 70
6353307 | 71
6353317 | 72
6353327 | 73
6353335 | 74
6353345 | 75
6353387 | 76
6353397 | 77
6353442 | 81
6353454 | 82
6353472 | 83
6353480 | 84
6353488 | 85
6353508 | 86
6353520 | 87
6353550 | 88
6353562 | 89
6353606 | 92
6353637 | 93
6353647 | 94
6353657 | 95
6353665 | 96
6353677 | 97
6353705 | 98
6353779 | 99
6353795 | 100
6353841 | 101
6353851 | 102
6353863 | 103
6353873 | 104
6353883 | 105
6353925 | 108
6353939 | 109
6353963 | 110
6354043 | 113
6356419 | 142
6356427 | 143
6356437 | 144
6356489 | 145
6356497 | 146
6356531 | 147
6356555 | 148
6356581 | 149
6356591 | 150
6356619 | 151

# IfcDistributionControlElement: Pavimento (56)
In: Piano 2 (+8.61)
Type - Altro - Categoria: Dispositivi allarme incendio; VVF_Visibilità_ARea_Influenza: yes; Nome famiglia: VVF_Rivelatore_fumo_controsoffitto
Type - Dati identità - Modello: PAVIMENTO; Nome del tipo: Pavimento; Numero OmniClass: 23.85.30.21.11.11.11; Titolo OmniClass: Smoke Detectors
Type - Dimensioni - Estremità - raggio piccolo: 0.038 m; Profondità base: 0.051 m; Profondità estremità: 0.038 m; Raggio base: 0.1 m; Raggio estremità: 0.051 m; VVF_Area_Influenza: 4.4 m
Type - Vincoli - Prospetto di default: 1.2 m
Altro - Livello abaco: Livello: Piano 3 (+12.85); Famiglia: VVF_Rivelatore_fumo_controsoffitto: Pavimento; Famiglia e tipo: VVF_Rivelatore_fumo_controsoffitto: Pavimento; ID tipo: VVF_Rivelatore_fumo_controsoffitto: Pavimento; Tipo: VVF_Rivelatore_fumo_controsoffitto: Pavimento
Dimensioni - Volume: 0.00204276 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Livello: Livello: Piano 3 (+12.85); Host: Livello : Piano 3 (+12.85); Offset: -0.25 m; Prospetto: -0.25 m
Name (VVF_Rivelatore_fumo_controsoffitto:Pavimento:...) | Contrassegno
6359960 | 203
6360080 | 204
6360110 | 205
6360118 | 206
6360183 | 207
6360193 | 208
6360199 | 209
6360342 | 210
6360350 | 211
6360393 | 212
6360441 | 213
6360449 | 214
6360507 | 215
6360513 | 216
6360521 | 217
6360529 | 218
6360565 | 219
6360575 | 220
6360600 | 221
6360676 | 222
6360700 | 223
6360723 | 224
6360752 | 225
6360794 | 226
6360821 | 227
6360856 | 228
6360884 | 229
6360915 | 230
6360940 | 231
6360948 | 232
6360962 | 233
6360970 | 234
6360980 | 235
6360990 | 236
6360996 | 237
6361027 | 238
6361035 | 239
6361076 | 240
6361100 | 241
6361154 | 242
6361214 | 243
6361220 | 244
6361228 | 245
6361236 | 246
6361348 | 247
6361369 | 248
6361392 | 249
6361398 | 250
6361426 | 251
6361436 | 252
6361444 | 253
6361452 | 254
6361460 | 255
6361479 | 256
6417242 | 257
6417282 | 258

# IfcDistributionControlElement: Semplice (43)
In: Piano 3 contr (+16.01) luci
Type - Altro - Categoria: Dispositivi allarme incendio; Nome famiglia: VVF_Rivelatore_fumo_soffitto; VVF_Visibilità_ARea_Influenza: yes
Type - Dati identità - Modello: SOFFITTO; Nome del tipo: Semplice; Numero OmniClass: 23.85.30.21.11.11.11; Titolo OmniClass: Smoke Detectors
Type - Dimensioni - Estremità - raggio piccolo: 0.038 m; Profondità base: 0.051 m; Profondità estremità: 0.038 m; Raggio base: 0.1 m; Raggio estremità: 0.051 m; VVF_Area_Influenza: 6.5 m
Type - Vincoli - Prospetto di default: 1.2 m
Altro - Famiglia: VVF_Rivelatore_fumo_soffitto: Semplice; Famiglia e tipo: VVF_Rivelatore_fumo_soffitto: Semplice; ID tipo: VVF_Rivelatore_fumo_soffitto: Semplice; Livello abaco: Livello: Piano 3 (+12.85); Tipo: VVF_Rivelatore_fumo_soffitto: Semplice
Dimensioni - Volume: 0.00204276 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Livello: Livello: Piano 3 (+12.85); Host: Modello di Revit collegato : 000070_000_RVM_ARC_ESE.rvt; Offset: 3.9 m; Prospetto: 3.9 m
Name (VVF_Rivelatore_fumo_soffitto:Semplice:...) | Contrassegno
6345160 | 15
6345170 | 16
6345202 | 19
6345216 | 20
6345224 | 21
6345234 | 22
6345242 | 23
6345250 | 24
6345258 | 25
6345268 | 26
6345278 | 27
6345290 | 28
6345298 | 29
6345306 | 30
6345316 | 31
6345377 | 33
6345397 | 35
6345437 | 37
6345447 | 38
6345477 | 39
6345487 | 40
6345497 | 41
6345509 | 42
6345519 | 43
6345529 | 44
6345541 | 45
6345551 | 46
6345559 | 47
6345569 | 48
6345581 | 49
6345593 | 50
6345623 | 53
6345631 | 54
6355040 | 117
6356668 | 153
6356678 | 154
6356701 | 155
6356709 | 156
6356732 | 157
6356752 | 158
6356758 | 159
6356779 | 160
6356859 | 161

# IfcDistributionControlElement: Semplice (38)
In: Piano 2 (+8.61)
Type - Altro - Categoria: Dispositivi allarme incendio; VVF_Visibilità_ARea_Influenza: yes; Nome famiglia: VVF_Rivelatore_termico_puntiforme
Type - Dati identità - Modello: TERMICO; Nome del tipo: Semplice; Numero OmniClass: 23.85.30.21.11.11.11; Titolo OmniClass: Smoke Detectors
Type - Dimensioni - Estremità - raggio piccolo: 0.038 m; Profondità base: 0.051 m; Profondità estremità: 0.038 m; Raggio base: 0.1 m; Raggio estremità: 0.051 m; VVF_Area_Influenza: 6.5 m
Type - Vincoli - Prospetto di default: 1.2 m
Altro - Famiglia: VVF_Rivelatore_termico_puntiforme: Semplice; Famiglia e tipo: VVF_Rivelatore_termico_puntiforme: Semplice; ID tipo: VVF_Rivelatore_termico_puntiforme: Semplice; Livello abaco: Livello: Piano 2 (+8.61); Tipo: VVF_Rivelatore_termico_puntiforme: Semplice
Dimensioni - Volume: 0.00204276 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Livello: Livello: Piano 2 (+8.61); Host: Livello : Piano 2 (+8.61); Offset: 3.3 m; Prospetto: 3.3 m
Name (VVF_Rivelatore_termico_puntiforme:Semplice:...) | Contrassegno
6358607 | 162
6359017 | 163
6359027 | 164
6359035 | 165
6359043 | 166
6359148 | 167
6359158 | 168
6359166 | 169
6359172 | 170
6359180 | 171
6359188 | 172
6359196 | 173
6359206 | 174
6359216 | 175
6359224 | 176
6359232 | 177
6359242 | 178
6359250 | 179
6359300 | 180
6359337 | 181
6359417 | 182
6359423 | 183
6359431 | 184
6359437 | 185
6359445 | 186
6359455 | 187
6359501 | 188
6359502 | 189
6359503 | 190
6359504 | 191
6359512 | 192
6359513 | 193
6359514 | 194
6359515 | 195
6359544 | 196
6359586 | 197
6359669 | 199
6359716 | 200

# IfcDistributionPort (13062)
Name | FlowDirection | Group
384 x  | SOURCEANDSINK | Protezione antincendio a secco 36
27 x  | SINK | Protezione antincendio a secco 36
27 x  | SOURCE | Protezione antincendio a secco 36
550 x  | SINK | Protezione antincendio a secco 35
550 x  | SOURCE | Protezione antincendio a secco 35
9068 x  | SOURCEANDSINK | Protezione antincendio a secco 35
6 x  | SINK | Protezione antincendio a secco 38
6 x  | SOURCE | Protezione antincendio a secco 38
62 x  | SOURCEANDSINK | Protezione antincendio a secco 38
4 x  | SOURCEANDSINK | Protezione antincendio a secco 132
5 x  | SINK | Protezione antincendio a secco 69
5 x  | SOURCE | Protezione antincendio a secco 69
62 x  | SOURCEANDSINK | Protezione antincendio a secco 69
2 x  | SINK | Protezione antincendio a secco 80
2 x  | SOURCE | Protezione antincendio a secco 80
20 x  | SOURCEANDSINK | Protezione antincendio a secco 80
2 x  | SINK | Protezione antincendio a secco 2
2 x  | SOURCE | Protezione antincendio a secco 2
24 x  | SOURCEANDSINK | Protezione antincendio a secco 2
4 x  | SINK | Protezione antincendio a secco 3
4 x  | SOURCE | Protezione antincendio a secco 3
28 x  | SOURCEANDSINK | Protezione antincendio a secco 3
8 x  | SOURCEANDSINK | Protezione antincendio a secco 5
 | SINK | Protezione antincendio a secco 7
 | SOURCE | Protezione antincendio a secco 7
4 x  | SOURCEANDSINK | Protezione antincendio a secco 7
 | SINK | Protezione antincendio a secco 1
 | SOURCE | Protezione antincendio a secco 1
 | SINK | Protezione antincendio a secco 6
 | SOURCE | Protezione antincendio a secco 6
16 x  | SOURCEANDSINK | Protezione antincendio a secco 6
4 x  | SOURCEANDSINK | Protezione antincendio a secco 1
4 x  | SOURCEANDSINK | Protezione antincendio a secco 12
8 x  | SOURCEANDSINK | Protezione antincendio a secco 17
 | SINK | Protezione antincendio a secco 11
 | SOURCE | Protezione antincendio a secco 11
 | SINK | Protezione antincendio a secco 13
 | SOURCE | Protezione antincendio a secco 13
16 x  | SOURCEANDSINK | Protezione antincendio a secco 13
4 x  | SOURCEANDSINK | Protezione antincendio a secco 11
4 x  | SOURCEANDSINK | Protezione antincendio a secco 18
8 x  | SOURCEANDSINK | Protezione antincendio a secco 23
 | SINK | Protezione antincendio a secco 16
 | SOURCE | Protezione antincendio a secco 16
 | SINK | Protezione antincendio a secco 19
 | SOURCE | Protezione antincendio a secco 19
16 x  | SOURCEANDSINK | Protezione antincendio a secco 19
4 x  | SOURCEANDSINK | Protezione antincendio a secco 16
4 x  | SOURCEANDSINK | Protezione antincendio a secco 24
8 x  | SOURCEANDSINK | Protezione antincendio a secco 29
 | SINK | Protezione antincendio a secco 22
 | SOURCE | Protezione antincendio a secco 22
 | SINK | Protezione antincendio a secco 25
 | SOURCE | Protezione antincendio a secco 25
16 x  | SOURCEANDSINK | Protezione antincendio a secco 25
4 x  | SOURCEANDSINK | Protezione antincendio a secco 22
4 x  | SOURCEANDSINK | Protezione antincendio a secco 30
8 x  | SOURCEANDSINK | Protezione antincendio a secco 39
 | SINK | Protezione antincendio a secco 28
 | SOURCE | Protezione antincendio a secco 28
 | SINK | Protezione antincendio a secco 31
 | SOURCE | Protezione antincendio a secco 31
16 x  | SOURCEANDSINK | Protezione antincendio a secco 31
4 x  | SOURCEANDSINK | Protezione antincendio a secco 28
4 x  | SOURCEANDSINK | Protezione antincendio a secco 41
8 x  | SOURCEANDSINK | Protezione antincendio a secco 46
 | SINK | Protezione antincendio a secco 34
 | SOURCE | Protezione antincendio a secco 34
 | SINK | Protezione antincendio a secco 42
 | SOURCE | Protezione antincendio a secco 42
16 x  | SOURCEANDSINK | Protezione antincendio a secco 42
4 x  | SOURCEANDSINK | Protezione antincendio a secco 34
4 x  | SOURCEANDSINK | Protezione antincendio a secco 47
8 x  | SOURCEANDSINK | Protezione antincendio a secco 52
 | SINK | Protezione antincendio a secco 45
 | SOURCE | Protezione antincendio a secco 45
 | SINK | Protezione antincendio a secco 48
 | SOURCE | Protezione antincendio a secco 48
16 x  | SOURCEANDSINK | Protezione antincendio a secco 48
4 x  | SOURCEANDSINK | Protezione antincendio a secco 45
14 x  | SOURCEANDSINK | Protezione antincendio a secco 58
 | SINK | Protezione antincendio a secco 51
 | SOURCE | Protezione antincendio a secco 51
 | SINK | Protezione antincendio a secco 54
 | SOURCE | Protezione antincendio a secco 54
16 x  | SOURCEANDSINK | Protezione antincendio a secco 54
14 x  | SOURCEANDSINK | Protezione antincendio a secco 51
 | SINK | Protezione antincendio a secco 65
 | SOURCE | Protezione antincendio a secco 65
4 x  | SOURCEANDSINK | Protezione antincendio a secco 65
 | SINK | Protezione antincendio a secco 55
 | SOURCE | Protezione antincendio a secco 55
 | SINK | Protezione antincendio a secco 56
 | SOURCE | Protezione antincendio a secco 56
16 x  | SOURCEANDSINK | Protezione antincendio a secco 56
14 x  | SOURCEANDSINK | Protezione antincendio a secco 55
 | SINK | Protezione antincendio a secco 72
 | SOURCE | Protezione antincendio a secco 72
4 x  | SOURCEANDSINK | Protezione antincendio a secco 72
 | SINK | Protezione antincendio a secco 60
 | SOURCE | Protezione antincendio a secco 60
 | SINK | Protezione antincendio a secco 61
 | SOURCE | Protezione antincendio a secco 61
16 x  | SOURCEANDSINK | Protezione antincendio a secco 61
14 x  | SOURCEANDSINK | Protezione antincendio a secco 60
 | SINK | Protezione antincendio a secco 78
 | SOURCE | Protezione antincendio a secco 78
4 x  | SOURCEANDSINK | Protezione antincendio a secco 78
 | SINK | Protezione antincendio a secco 64
 | SOURCE | Protezione antincendio a secco 64
 | SINK | Protezione antincendio a secco 66
 | SOURCE | Protezione antincendio a secco 66
16 x  | SOURCEANDSINK | Protezione antincendio a secco 66
14 x  | SOURCEANDSINK | Protezione antincendio a secco 64
 | SINK | Protezione antincendio a secco 85
 | SOURCE | Protezione antincendio a secco 85
4 x  | SOURCEANDSINK | Protezione antincendio a secco 85
 | SINK | Protezione antincendio a secco 71
 | SOURCE | Protezione antincendio a secco 71
 | SINK | Protezione antincendio a secco 73
 | SOURCE | Protezione antincendio a secco 73
16 x  | SOURCEANDSINK | Protezione antincendio a secco 73
14 x  | SOURCEANDSINK | Protezione antincendio a secco 71
 | SINK | Protezione antincendio a secco 91
 | SOURCE | Protezione antincendio a secco 91
4 x  | SOURCEANDSINK | Protezione antincendio a secco 91
 | SINK | Protezione antincendio a secco 79
 | SOURCE | Protezione antincendio a secco 79
16 x  | SOURCEANDSINK | Protezione antincendio a secco 79
 | SINK | Protezione antincendio a secco 97
 | SOURCE | Protezione antincendio a secco 97
4 x  | SOURCEANDSINK | Protezione antincendio a secco 97
 | SINK | Protezione antincendio a secco 86
 | SOURCE | Protezione antincendio a secco 86
16 x  | SOURCEANDSINK | Protezione antincendio a secco 86
 | SINK | Protezione antincendio a secco 103
 | SOURCE | Protezione antincendio a secco 103
4 x  | SOURCEANDSINK | Protezione antincendio a secco 103
 | SINK | Protezione antincendio a secco 92
 | SOURCE | Protezione antincendio a secco 92
16 x  | SOURCEANDSINK | Protezione antincendio a secco 92
 | SINK | Protezione antincendio a secco 109
 | SOURCE | Protezione antincendio a secco 109
4 x  | SOURCEANDSINK | Protezione antincendio a secco 109
 | SINK | Protezione antincendio a secco 98
 | SOURCE | Protezione antincendio a secco 98
16 x  | SOURCEANDSINK | Protezione antincendio a secco 98
 | SINK | Protezione antincendio a secco 115
 | SOURCE | Protezione antincendio a secco 115
4 x  | SOURCEANDSINK | Protezione antincendio a secco 115
 | SINK | Protezione antincendio a secco 104
 | SOURCE | Protezione antincendio a secco 104
16 x  | SOURCEANDSINK | Protezione antincendio a secco 104
 | SINK | Protezione antincendio a secco 121
 | SOURCE | Protezione antincendio a secco 121
4 x  | SOURCEANDSINK | Protezione antincendio a secco 121
 | SINK | Protezione antincendio a secco 110
 | SOURCE | Protezione antincendio a secco 110
16 x  | SOURCEANDSINK | Protezione antincendio a secco 110
 | SINK | Protezione antincendio a secco 127
 | SOURCE | Protezione antincendio a secco 127
4 x  | SOURCEANDSINK | Protezione antincendio a secco 127
 | SINK | Protezione antincendio a secco 116
 | SOURCE | Protezione antincendio a secco 116
16 x  | SOURCEANDSINK | Protezione antincendio a secco 116
 | SINK | Protezione antincendio a secco 134
 | SOURCE | Protezione antincendio a secco 134
4 x  | SOURCEANDSINK | Protezione antincendio a secco 134
 | SINK | Protezione antincendio a secco 122
 | SOURCE | Protezione antincendio a secco 122
16 x  | SOURCEANDSINK | Protezione antincendio a secco 122
 | SINK | Protezione antincendio a secco 141
 | SOURCE | Protezione antincendio a secco 141
4 x  | SOURCEANDSINK | Protezione antincendio a secco 141
 | SINK | Protezione antincendio a secco 128
 | SOURCE | Protezione antincendio a secco 128
16 x  | SOURCEANDSINK | Protezione antincendio a secco 128
 | SINK | Protezione antincendio a secco 147
 | SOURCE | Protezione antincendio a secco 147
4 x  | SOURCEANDSINK | Protezione antincendio a secco 147
 | SINK | Protezione antincendio a secco 95
 | SOURCE | Protezione antincendio a secco 95
16 x  | SOURCEANDSINK | Protezione antincendio a secco 95
 | SINK | Protezione antincendio a secco 139
 | SOURCE | Protezione antincendio a secco 139
4 x  | SOURCEANDSINK | Protezione antincendio a secco 139
 | SINK | Protezione antincendio a secco 107
 | SOURCE | Protezione antincendio a secco 107
16 x  | SOURCEANDSINK | Protezione antincendio a secco 107
 | SINK | Protezione antincendio a secco 146
 | SOURCE | Protezione antincendio a secco 146
4 x  | SOURCEANDSINK | Protezione antincendio a secco 146
 | SINK | Protezione antincendio a secco 125
 | SOURCE | Protezione antincendio a secco 125
16 x  | SOURCEANDSINK | Protezione antincendio a secco 125
 | SINK | Protezione antincendio a secco 153
 | SOURCE | Protezione antincendio a secco 153
4 x  | SOURCEANDSINK | Protezione antincendio a secco 153
 | SINK | Protezione antincendio a secco 135
 | SOURCE | Protezione antincendio a secco 135
16 x  | SOURCEANDSINK | Protezione antincendio a secco 135
 | SINK | Protezione antincendio a secco 158
 | SOURCE | Protezione antincendio a secco 158
4 x  | SOURCEANDSINK | Protezione antincendio a secco 158
 | SINK | Protezione antincendio a secco 145
 | SOURCE | Protezione antincendio a secco 145
16 x  | SOURCEANDSINK | Protezione antincendio a secco 145
 | SINK | Protezione antincendio a secco 163
 | SOURCE | Protezione antincendio a secco 163
4 x  | SOURCEANDSINK | Protezione antincendio a secco 163
 | SINK | Protezione antincendio a secco 152
 | SOURCE | Protezione antincendio a secco 152
16 x  | SOURCEANDSINK | Protezione antincendio a secco 152
 | SINK | Protezione antincendio a secco 168
 | SOURCE | Protezione antincendio a secco 168
4 x  | SOURCEANDSINK | Protezione antincendio a secco 168
 | SINK | Protezione antincendio a secco 157
 | SOURCE | Protezione antincendio a secco 157
16 x  | SOURCEANDSINK | Protezione antincendio a secco 157
 | SINK | Protezione antincendio a secco 173
 | SOURCE | Protezione antincendio a secco 173
4 x  | SOURCEANDSINK | Protezione antincendio a secco 173
 | SINK | Protezione antincendio a secco 162
 | SOURCE | Protezione antincendio a secco 162
16 x  | SOURCEANDSINK | Protezione antincendio a secco 162
 | SINK | Protezione antincendio a secco 178
 | SOURCE | Protezione antincendio a secco 178
4 x  | SOURCEANDSINK | Protezione antincendio a secco 178
 | SINK | Protezione antincendio a secco 167
 | SOURCE | Protezione antincendio a secco 167
16 x  | SOURCEANDSINK | Protezione antincendio a secco 167
 | SINK | Protezione antincendio a secco 183
 | SOURCE | Protezione antincendio a secco 183
4 x  | SOURCEANDSINK | Protezione antincendio a secco 183
 | SINK | Protezione antincendio a secco 172
 | SOURCE | Protezione antincendio a secco 172
16 x  | SOURCEANDSINK | Protezione antincendio a secco 172
 | SINK | Protezione antincendio a secco 188
 | SOURCE | Protezione antincendio a secco 188
4 x  | SOURCEANDSINK | Protezione antincendio a secco 188
 | SINK | Protezione antincendio a secco 177
 | SOURCE | Protezione antincendio a secco 177
16 x  | SOURCEANDSINK | Protezione antincendio a secco 177
 | SINK | Protezione antincendio a secco 193
 | SOURCE | Protezione antincendio a secco 193
4 x  | SOURCEANDSINK | Protezione antincendio a secco 193
 | SINK | Protezione antincendio a secco 182
 | SOURCE | Protezione antincendio a secco 182
16 x  | SOURCEANDSINK | Protezione antincendio a secco 182
 | SINK | Protezione antincendio a secco 198
 | SOURCE | Protezione antincendio a secco 198
4 x  | SOURCEANDSINK | Protezione antincendio a secco 198
 | SINK | Protezione antincendio a secco 187
 | SOURCE | Protezione antincendio a secco 187
16 x  | SOURCEANDSINK | Protezione antincendio a secco 187
 | SINK | Protezione antincendio a secco 203
 | SOURCE | Protezione antincendio a secco 203
4 x  | SOURCEANDSINK | Protezione antincendio a secco 203
 | SINK | Protezione antincendio a secco 192
 | SOURCE | Protezione antincendio a secco 192
16 x  | SOURCEANDSINK | Protezione antincendio a secco 192
 | SINK | Protezione antincendio a secco 208
 | SOURCE | Protezione antincendio a secco 208
4 x  | SOURCEANDSINK | Protezione antincendio a secco 208
 | SINK | Protezione antincendio a secco 197
 | SOURCE | Protezione antincendio a secco 197
16 x  | SOURCEANDSINK | Protezione antincendio a secco 197
 | SINK | Protezione antincendio a secco 213
 | SOURCE | Protezione antincendio a secco 213
4 x  | SOURCEANDSINK | Protezione antincendio a secco 213
 | SINK | Protezione antincendio a secco 202
 | SOURCE | Protezione antincendio a secco 202
16 x  | SOURCEANDSINK | Protezione antincendio a secco 202
 | SINK | Protezione antincendio a secco 218
 | SOURCE | Protezione antincendio a secco 218
4 x  | SOURCEANDSINK | Protezione antincendio a secco 218
 | SINK | Protezione antincendio a secco 206
 | SOURCE | Protezione antincendio a secco 206
 | SINK | Protezione antincendio a secco 207
 | SOURCE | Protezione antincendio a secco 207
16 x  | SOURCEANDSINK | Protezione antincendio a secco 207
14 x  | SOURCEANDSINK | Protezione antincendio a secco 206
 | SINK | Protezione antincendio a secco 224
 | SOURCE | Protezione antincendio a secco 224
4 x  | SOURCEANDSINK | Protezione antincendio a secco 224
 | SINK | Protezione antincendio a secco 217
 | SOURCE | Protezione antincendio a secco 217
 | SINK | Protezione antincendio a secco 219
 | SOURCE | Protezione antincendio a secco 219
16 x  | SOURCEANDSINK | Protezione antincendio a secco 219
4 x  | SOURCEANDSINK | Protezione antincendio a secco 217
4 x  | SOURCEANDSINK | Protezione antincendio a secco 225
8 x  | SOURCEANDSINK | Protezione antincendio a secco 231
 | SINK | Protezione antincendio a secco 223
 | SOURCE | Protezione antincendio a secco 223
 | SINK | Protezione antincendio a secco 227
 | SOURCE | Protezione antincendio a secco 227
16 x  | SOURCEANDSINK | Protezione antincendio a secco 227
4 x  | SOURCEANDSINK | Protezione antincendio a secco 223
4 x  | SOURCEANDSINK | Protezione antincendio a secco 232
8 x  | SOURCEANDSINK | Protezione antincendio a secco 237
 | SINK | Protezione antincendio a secco 230
 | SOURCE | Protezione antincendio a secco 230
 | SINK | Protezione antincendio a secco 233
 | SOURCE | Protezione antincendio a secco 233
16 x  | SOURCEANDSINK | Protezione antincendio a secco 233
4 x  | SOURCEANDSINK | Protezione antincendio a secco 230
4 x  | SOURCEANDSINK | Protezione antincendio a secco 238
8 x  | SOURCEANDSINK | Protezione antincendio a secco 243
 | SINK | Protezione antincendio a secco 236
 | SOURCE | Protezione antincendio a secco 236
 | SINK | Protezione antincendio a secco 239
 | SOURCE | Protezione antincendio a secco 239
16 x  | SOURCEANDSINK | Protezione antincendio a secco 239
4 x  | SOURCEANDSINK | Protezione antincendio a secco 236
4 x  | SOURCEANDSINK | Protezione antincendio a secco 244
8 x  | SOURCEANDSINK | Protezione antincendio a secco 249
 | SINK | Protezione antincendio a secco 242
 | SOURCE | Protezione antincendio a secco 242
 | SINK | Protezione antincendio a secco 245
 | SOURCE | Protezione antincendio a secco 245
16 x  | SOURCEANDSINK | Protezione antincendio a secco 245
4 x  | SOURCEANDSINK | Protezione antincendio a secco 242
4 x  | SOURCEANDSINK | Protezione antincendio a secco 250
8 x  | SOURCEANDSINK | Protezione antincendio a secco 255
 | SINK | Protezione antincendio a secco 248
 | SOURCE | Protezione antincendio a secco 248
 | SINK | Protezione antincendio a secco 251
 | SOURCE | Protezione antincendio a secco 251
16 x  | SOURCEANDSINK | Protezione antincendio a secco 251
4 x  | SOURCEANDSINK | Protezione antincendio a secco 248
4 x  | SOURCEANDSINK | Protezione antincendio a secco 256
8 x  | SOURCEANDSINK | Protezione antincendio a secco 261
 | SINK | Protezione antincendio a secco 254
 | SOURCE | Protezione antincendio a secco 254
 | SINK | Protezione antincendio a secco 257
 | SOURCE | Protezione antincendio a secco 257
16 x  | SOURCEANDSINK | Protezione antincendio a secco 257
4 x  | SOURCEANDSINK | Protezione antincendio a secco 254
4 x  | SOURCEANDSINK | Protezione antincendio a secco 262
8 x  | SOURCEANDSINK | Protezione antincendio a secco 267
 | SINK | Protezione antincendio a secco 260
 | SOURCE | Protezione antincendio a secco 260
 | SINK | Protezione antincendio a secco 263
 | SOURCE | Protezione antincendio a secco 263
16 x  | SOURCEANDSINK | Protezione antincendio a secco 263
4 x  | SOURCEANDSINK | Protezione antincendio a secco 260
4 x  | SOURCEANDSINK | Protezione antincendio a secco 268
8 x  | SOURCEANDSINK | Protezione antincendio a secco 273
 | SINK | Protezione antincendio a secco 266
 | SOURCE | Protezione antincendio a secco 266
 | SINK | Protezione antincendio a secco 269
 | SOURCE | Protezione antincendio a secco 269
16 x  | SOURCEANDSINK | Protezione antincendio a secco 269
4 x  | SOURCEANDSINK | Protezione antincendio a secco 266
4 x  | SOURCEANDSINK | Protezione antincendio a secco 274
8 x  | SOURCEANDSINK | Protezione antincendio a secco 279
 | SINK | Protezione antincendio a secco 272
 | SOURCE | Protezione antincendio a secco 272
 | SINK | Protezione antincendio a secco 275
 | SOURCE | Protezione antincendio a secco 275
16 x  | SOURCEANDSINK | Protezione antincendio a secco 275
4 x  | SOURCEANDSINK | Protezione antincendio a secco 272
 | SINK | Protezione antincendio a secco 281
 | SOURCE | Protezione antincendio a secco 281
 | SINK | Protezione antincendio a secco 282
 | SOURCE | Protezione antincendio a secco 282
16 x  | SOURCEANDSINK | Protezione antincendio a secco 282
4 x  | SOURCEANDSINK | Protezione antincendio a secco 281
8 x  | SOURCEANDSINK | Protezione antincendio a secco 288
 | SINK | Protezione antincendio a secco 53
 | SOURCE | Protezione antincendio a secco 53
 | SINK | Protezione antincendio a secco 286
 | SOURCE | Protezione antincendio a secco 286
16 x  | SOURCEANDSINK | Protezione antincendio a secco 286
4 x  | SOURCEANDSINK | Protezione antincendio a secco 53
8 x  | SOURCEANDSINK | Protezione antincendio a secco 293
 | SINK | Protezione antincendio a secco 290
 | SOURCE | Protezione antincendio a secco 290
 | SINK | Protezione antincendio a secco 291
 | SOURCE | Protezione antincendio a secco 291
28 x  | SOURCEANDSINK | Protezione antincendio a secco 291
4 x  | SOURCEANDSINK | Protezione antincendio a secco 290
14 x  | SOURCEANDSINK | Protezione antincendio a secco 300
 | SINK | Protezione antincendio a secco 298
 | SOURCE | Protezione antincendio a secco 298
 | SINK | Protezione antincendio a secco 299
 | SOURCE | Protezione antincendio a secco 299
16 x  | SOURCEANDSINK | Protezione antincendio a secco 299
4 x  | SOURCEANDSINK | Protezione antincendio a secco 298
8 x  | SOURCEANDSINK | Protezione antincendio a secco 305
 | SINK | Protezione antincendio a secco 302
 | SOURCE | Protezione antincendio a secco 302
 | SINK | Protezione antincendio a secco 303
 | SOURCE | Protezione antincendio a secco 303
16 x  | SOURCEANDSINK | Protezione antincendio a secco 303
4 x  | SOURCEANDSINK | Protezione antincendio a secco 302
8 x  | SOURCEANDSINK | Protezione antincendio a secco 310
 | SINK | Protezione antincendio a secco 306
 | SOURCE | Protezione antincendio a secco 306
 | SINK | Protezione antincendio a secco 308
 | SOURCE | Protezione antincendio a secco 308
16 x  | SOURCEANDSINK | Protezione antincendio a secco 308
4 x  | SOURCEANDSINK | Protezione antincendio a secco 306
8 x  | SOURCEANDSINK | Protezione antincendio a secco 315
 | SINK | Protezione antincendio a secco 311
 | SOURCE | Protezione antincendio a secco 311
 | SINK | Protezione antincendio a secco 313
 | SOURCE | Protezione antincendio a secco 313
16 x  | SOURCEANDSINK | Protezione antincendio a secco 313
4 x  | SOURCEANDSINK | Protezione antincendio a secco 311
8 x  | SOURCEANDSINK | Protezione antincendio a secco 320
 | SINK | Protezione antincendio a secco 316
 | SOURCE | Protezione antincendio a secco 316
 | SINK | Protezione antincendio a secco 318
 | SOURCE | Protezione antincendio a secco 318
16 x  | SOURCEANDSINK | Protezione antincendio a secco 318
4 x  | SOURCEANDSINK | Protezione antincendio a secco 316
8 x  | SOURCEANDSINK | Protezione antincendio a secco 325
 | SINK | Protezione antincendio a secco 321
 | SOURCE | Protezione antincendio a secco 321
 | SINK | Protezione antincendio a secco 323
 | SOURCE | Protezione antincendio a secco 323
16 x  | SOURCEANDSINK | Protezione antincendio a secco 323
4 x  | SOURCEANDSINK | Protezione antincendio a secco 321
8 x  | SOURCEANDSINK | Protezione antincendio a secco 330
 | SINK | Protezione antincendio a secco 326
 | SOURCE | Protezione antincendio a secco 326
 | SINK | Protezione antincendio a secco 328
 | SOURCE | Protezione antincendio a secco 328
16 x  | SOURCEANDSINK | Protezione antincendio a secco 328
4 x  | SOURCEANDSINK | Protezione antincendio a secco 326
8 x  | SOURCEANDSINK | Protezione antincendio a secco 335
 | SINK | Protezione antincendio a secco 331
 | SOURCE | Protezione antincendio a secco 331
 | SINK | Protezione antincendio a secco 333
 | SOURCE | Protezione antincendio a secco 333
16 x  | SOURCEANDSINK | Protezione antincendio a secco 333
4 x  | SOURCEANDSINK | Protezione antincendio a secco 331
14 x  | SOURCEANDSINK | Protezione antincendio a secco 344
 | SINK | Protezione antincendio a secco 338
 | SOURCE | Protezione antincendio a secco 338
 | SINK | Protezione antincendio a secco 340
 | SOURCE | Protezione antincendio a secco 340
16 x  | SOURCEANDSINK | Protezione antincendio a secco 340
4 x  | SOURCEANDSINK | Protezione antincendio a secco 338
8 x  | SOURCEANDSINK | Protezione antincendio a secco 346
 | SINK | Protezione antincendio a secco 20
 | SOURCE | Protezione antincendio a secco 20
 | SINK | Protezione antincendio a secco 26
 | SOURCE | Protezione antincendio a secco 26
16 x  | SOURCEANDSINK | Protezione antincendio a secco 26
4 x  | SOURCEANDSINK | Protezione antincendio a secco 20
 | SINK | Protezione antincendio a secco 8
 | SOURCE | Protezione antincendio a secco 8
 | SINK | Protezione antincendio a secco 14
 | SOURCE | Protezione antincendio a secco 14
16 x  | SOURCEANDSINK | Protezione antincendio a secco 14
4 x  | SOURCEANDSINK | Protezione antincendio a secco 8
14 x  | SOURCEANDSINK | Protezione antincendio a secco 84
 | SINK | Protezione antincendio a secco 43
 | SOURCE | Protezione antincendio a secco 43
 | SINK | Protezione antincendio a secco 59
 | SOURCE | Protezione antincendio a secco 59
16 x  | SOURCEANDSINK | Protezione antincendio a secco 59
4 x  | SOURCEANDSINK | Protezione antincendio a secco 43
22 x  | SOURCEANDSINK | Protezione antincendio a secco 83
 | SINK | Protezione antincendio a secco 70
 | SOURCE | Protezione antincendio a secco 70
 | SINK | Protezione antincendio a secco 76
 | SOURCE | Protezione antincendio a secco 76
16 x  | SOURCEANDSINK | Protezione antincendio a secco 76
4 x  | SOURCEANDSINK | Protezione antincendio a secco 70
20 x  | SOURCEANDSINK | Protezione antincendio a secco 101
 | SINK | Protezione antincendio a secco 101
 | SOURCE | Protezione antincendio a secco 101
14 x  | SOURCEANDSINK | Protezione antincendio a secco 96
2 x  | SINK | Protezione antincendio a secco 96
2 x  | SOURCE | Protezione antincendio a secco 96
 | SINK | Protezione antincendio a secco 196
 | SOURCE | Protezione antincendio a secco 196
 | SINK | Protezione antincendio a secco 201
 | SOURCE | Protezione antincendio a secco 201
4 x  | SOURCEANDSINK | Protezione antincendio a secco 196
4 x  | SOURCEANDSINK | Protezione antincendio a secco 201
 | SINK | Protezione antincendio a secco 234
 | SOURCE | Protezione antincendio a secco 234
4 x  | SOURCEANDSINK | Protezione antincendio a secco 234
 | SINK | Protezione antincendio a secco 264
 | SOURCE | Protezione antincendio a secco 264
2 x  | SINK | Protezione antincendio a secco 40
2 x  | SOURCE | Protezione antincendio a secco 40
16 x  | SOURCEANDSINK | Protezione antincendio a secco 40
8 x  | SOURCEANDSINK | Protezione antincendio a secco 90
 | SINK | Protezione antincendio a secco 90
 | SOURCE | Protezione antincendio a secco 90
 | SINK | Protezione antincendio a secco 108
 | SOURCE | Protezione antincendio a secco 108
5 x  | SINK | Protezione antincendio a secco 114
5 x  | SOURCE | Protezione antincendio a secco 114
8 x  | SOURCEANDSINK | Protezione antincendio a secco 108
66 x  | SOURCEANDSINK | Protezione antincendio a secco 114
 | SINK | Protezione antincendio a secco 120
 | SOURCE | Protezione antincendio a secco 120
6 x  | SOURCEANDSINK | Protezione antincendio a secco 120
 | SINK | Protezione antincendio a secco 156
 | SOURCE | Protezione antincendio a secco 156
 | SINK | Protezione antincendio a secco 161
 | SOURCE | Protezione antincendio a secco 161
4 x  | SOURCEANDSINK | Protezione antincendio a secco 156
4 x  | SOURCEANDSINK | Protezione antincendio a secco 161
 | SINK | Protezione antincendio a secco 176
 | SOURCE | Protezione antincendio a secco 176
4 x  | SOURCEANDSINK | Protezione antincendio a secco 176
 | SINK | Protezione antincendio a secco 151
 | SOURCE | Protezione antincendio a secco 151
8 x  | SOURCEANDSINK | Protezione antincendio a secco 151
 | SINK | Protezione antincendio a secco 166
 | SOURCE | Protezione antincendio a secco 166
8 x  | SOURCEANDSINK | Protezione antincendio a secco 166

# IfcFlowFitting: Standard, M_Calotta - Saldata - Generica:Standard:6388192
In: PR_VVF_0200_SPR_Sezione su scala
Type - Altro - Categoria: Raccordi tubazione; Nome famiglia: M_Calotta - Saldata - Generica; Nome tabella di ricerca: M_Cap - Welded - Generic
Type - Dati identità - Nome del tipo: Standard; Numero OmniClass: 23.60.30.11.14; Titolo OmniClass: Pipework Fittings
Type - Meccanica - Metodo di perdita: Non definito
Pset_DistributionFlowElementCommon - Reference: Standard
Altro - Famiglia: M_Calotta - Saldata - Generica: Standard; Famiglia e tipo: M_Calotta - Saldata - Generica: Standard; ID tipo: M_Calotta - Saldata - Generica: Standard; Raggio esterno raccordo: 0.04445 m; Tipo: M_Calotta - Saldata - Generica: Standard
Dati identità - Commenti: rampa 0-1; Contrassegno: VE4612
Dimensioni - Diametro esterno raccordo: 0.0889 m; Diametro nominale: 0.08 m; Dimensione massima: 0.08 m; Dimensione minima: 0.08 m; Dimensioni: ø80; Raggio nominale: 0.04 m; Spessore tappo: 0.025 m; Volume: 0.000155172 m3
Fasi - Fase di creazione: Stato di Progetto
Grafica - Utilizza scala di annotazione: yes
Isolamento - Spessore isolamento: 0 m; Dimensione totale: ø80 mm
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco; Classificazione sistema: Protezione antincendio a secco; Nome sistema: Protezione antincendio a secco 35
Meccanico - Flusso - Caduta pressione: 0 Pa
Testo - Tipologia impianto: impianto a secco
Vincoli - Livello: Livello: PR_VVF_0200_SPR_Sezione su scala; Host: Livello : PR_VVF_0200_SPR_Sezione su scala; Offset: 7.4332 m
Group: Protezione antincendio a secco 35

# IfcFlowFitting: Standard (236)
Type - Altro - Categoria: Raccordi tubazione; Nome famiglia: M_Croce - Filettata - MI - Classe 150; Nome tabella di ricerca: M_Cross - Threaded - MI - Class 150
Type - Dati identità - Commenti sul tipo: Croce; Descrizione: Croce; Nome del tipo: Standard; Numero OmniClass: 23.60.30.11.14; Titolo OmniClass: Pipework Fittings
Type - Meccanica - Metodo di perdita: Non definito
Pset_DistributionFlowElementCommon - Reference: Standard
Altro - Famiglia: M_Croce - Filettata - MI - Classe 150: Standard; Famiglia e tipo: M_Croce - Filettata - MI - Classe 150: Standard; ID tipo: M_Croce - Filettata - MI - Classe 150: Standard; Tipo: M_Croce - Filettata - MI - Classe 150: Standard
Fasi - Fase di creazione: Stato di Progetto
Grafica - Utilizza scala di annotazione: yes
Isolamento - Spessore isolamento: 0 m
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco
Name (M_Croce - Filettata - MI - Classe 150:Standard:...) | In | Angolo 3 (deg) | Angolo 4 (deg) | Angolo 5 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Lunghezza 7 (m) | Lunghezza 8 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo 1 (deg) | Angolo 2 (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6271409 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6271791 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6273673 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6273764 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6276734 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278064 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278860 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279076 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279186 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279296 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279408 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279520 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279630 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281118 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281340 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281450 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
