Properties of the parts of a building model (IFC2X3), part 37 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6293765 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.0905 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.525401 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 577 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6293881 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 521 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6293907 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 524 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294055 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 529 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294079 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 572 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294215 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 658 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294228 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 680 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294254 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 702 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294277 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 724 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294312 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 746 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294347 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 30 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294360 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.45935 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.869429 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3084 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6294647 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.60293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282973 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3219 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294650 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.62286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.284539 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3208 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294664 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3208 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294670 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3211 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294672 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.6 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.361911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3206 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294675 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3207 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294682 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3214 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294684 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3222 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294686 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3219 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294690 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.496895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0624417 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3204 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294693 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3205 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294698 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3218 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294703 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.8095 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282442 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3217 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294712 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.55884 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.894434 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3176 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294720 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3198 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294730 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3190 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294734 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3193 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294736 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3201 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294738 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3198 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294740 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3187 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294746 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3197 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294751 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3196 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294768 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3190 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294770 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3189 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294776 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 64 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294786 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 56 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294790 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 59 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294792 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 67 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294794 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 64 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294796 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3183 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294802 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 63 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294807 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 62 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294824 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 56 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294826 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3185 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294832 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 82 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294842 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 77 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294844 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 85 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294846 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 82 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294848 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.841895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.105796 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 72 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294854 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 81 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294859 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 80 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294872 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 73 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294874 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.99527 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.752793 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3177 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294876 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3178 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294882 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 69 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294884 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1229 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294886 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.46813 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.272386 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1160 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294889 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.52286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1149 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294899 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1149 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294905 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1152 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294907 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1147 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294910 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1148 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294917 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1155 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294919 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1163 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294921 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1160 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294925 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.791195 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994245 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1145 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294928 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1146 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294933 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.0774679 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00778792 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1159 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294938 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3538 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.23663 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1158 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294949 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.46813 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.272386 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 908 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294959 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 897 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294965 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 900 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294967 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 895 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294975 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 903 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294977 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 911 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294979 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 908 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6294983 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 893 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294986 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 894 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294991 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.0774679 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00778792 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 907 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6294996 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 906 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295011 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.44742 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.27076 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 897 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295013 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.984139 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0772941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 897 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295016 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295019 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295030 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 69 | Dati identità - Commenti: Stacco
6295036 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 69 | Dati identità - Commenti: Stacco
6295038 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295041 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295048 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 69 | Dati identità - Commenti: Stacco
6295050 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 28 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 69 | Dati identità - Commenti: Stacco
6295052 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 26 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 69 | Dati identità - Commenti: Stacco
6295056 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 12 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295059 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295064 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 25 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295069 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 69 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 24 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 69
6295085 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1246 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295088 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1235 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295099 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1235 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295105 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1238 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295107 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1233 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295110 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1234 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295117 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1241 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295119 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1249 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295121 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1246 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295125 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1231 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295128 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1232 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295133 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1245 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295138 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1244 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295154 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1267 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295157 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1256 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295168 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1256 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295174 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1259 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295176 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1254 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295179 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1255 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295186 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1262 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295188 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1270 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295190 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1267 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6295194 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1252 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295197 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1253 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6295202 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1266 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
