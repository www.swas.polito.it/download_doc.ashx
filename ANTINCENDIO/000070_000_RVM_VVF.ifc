Properties of the parts of a building model (IFC2X3), part 56 of 58

# IfcFlowTerminal: VVF_tipo_VK520_upright (752)
Name (VVF_tipo_VK520_upright:VVF_tipo_VK520_upright:...) | In | Contrassegno | Nome sistema | Tipo di sistema | Tipologia impianto | Host | Livello | Offset (m) | Group
6296032 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296033 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296034 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296089 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296092 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296095 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296096 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296097 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296152 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296155 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296158 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296159 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296160 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296215 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296218 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296221 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296222 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296223 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296284 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296287 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296290 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296291 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296292 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296353 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296356 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296359 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296360 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296361 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296422 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296425 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296428 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296429 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296430 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296491 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296494 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296497 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296498 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296499 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296560 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296563 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296566 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296567 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296568 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296629 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296632 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296635 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296636 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296637 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296700 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296701 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296702 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296703 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296756 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296757 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296758 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296759 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6296840 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.29786 | Protezione antincendio a secco 35
6296847 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297020 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297021 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297022 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297059 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297060 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297061 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297112 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297113 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297144 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297145 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297172 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6297173 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6298983 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.30059 | Protezione antincendio a secco 35
6300246 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6300247 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6300539 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6300542 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6300545 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6302021 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6302022 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6302580 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6302581 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6302582 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6302693 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6302694 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6305920 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6305921 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306044 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306045 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306048 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306190 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306191 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306194 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306257 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306258 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306261 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306324 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306325 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306328 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306391 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306392 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306395 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306460 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306461 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306464 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306527 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306528 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306531 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306594 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306595 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306598 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306663 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306664 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306667 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306730 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306731 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306734 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306797 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306798 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306801 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306862 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306863 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306866 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306929 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306930 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306933 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306996 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6306997 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6307000 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4 | Protezione antincendio a secco 35
6307538 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307539 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307583 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307584 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307687 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307688 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307689 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307754 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307755 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307756 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307821 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307822 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307823 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307888 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307889 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307890 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307955 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307956 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6307957 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308022 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308023 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308024 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308089 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308090 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308091 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308156 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308157 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308158 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308223 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308224 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308225 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308290 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308291 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308292 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308357 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308358 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308359 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308518 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308519 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308567 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308568 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308686 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308687 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308733 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308734 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308787 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308788 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308789 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308854 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308855 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308856 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308940 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308941 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6308987 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 80 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 80
6308988 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 80 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 80
6309081 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6309082 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6309083 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6309339 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6309340 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.1 | Protezione antincendio a secco 35
6314012 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 2 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 2
6314015 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 2 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 2
6314018 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6314276 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 3 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 3
6314277 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 3 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 3
6316631 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 7 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 7
6318212 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 1 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 1
6318213 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 6 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 6
6318216 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6318329 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 11 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 11
6318330 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 13 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 13
6318333 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6318448 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 16 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 16
6318449 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 19 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 19
6318452 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6318567 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 22 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 22
6318568 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 25 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 25
6318571 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6318686 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 28 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 28
6318687 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 31 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 31
6318690 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6318801 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 34 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 34
6318802 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 42 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 42
6318805 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6318928 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 45 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 45
6318929 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 48 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 48
6318932 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 35
6319082 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 51 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 51
6319083 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 54 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 54
6319137 | Piano 3 (+12.85) | Piano Uffici | Protezione antincendio a secco 65 | Sistema di tubazioni: Protezione antincendio a secco | impianto a umido | Livello : Piano 3 (+12.85) | Livello: Piano 3 (+12.85) | 3.86 | Protezione antincendio a secco 65
