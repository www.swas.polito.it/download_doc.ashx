Properties of the parts of a building model (IFC2X3), part 7 of 58

# IfcFlowFitting: Standard (475)
Name (M_Raccordo a T - Filettato - MI - Classe 150:Standard:...) | In | Angolo 1 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6273754 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6276696 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6276714 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6276724 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278026 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278044 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278054 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278822 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278840 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6278850 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 38 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279038 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279056 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279066 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279148 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279166 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279176 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279258 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279276 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279286 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279370 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279388 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279398 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279482 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279500 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279510 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279592 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279610 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279620 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279702 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279720 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279730 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279812 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279830 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279840 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279926 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279944 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6279954 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280036 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280054 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280064 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280146 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280164 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280174 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280258 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280276 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280366 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280384 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280480 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280498 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280508 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280594 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280612 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280622 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280706 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280724 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280734 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280858 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280876 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280886 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280970 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280988 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6280998 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281080 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281098 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281108 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281192 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281210 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281220 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281302 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281320 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281330 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281412 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281430 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281440 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281522 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281540 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281550 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281632 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281650 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281660 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281766 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281784 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281794 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281908 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281916 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6282000 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6282008 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6284008 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288365 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288379 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288443 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288457 | Piano 2 (+8.61) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Secondo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288654 | Piano 2 (+8.61) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288860 | Piano 2 (+8.61) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288930 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6288992 | Piano 2 (+8.61) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6289265 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6289271 | Piano 2 (+8.61) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6289316 | Piano 2 (+8.61) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Secondo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6289322 | Piano 2 (+8.61) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291978 | Piano 2 (+8.61) | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00311053 | ø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6294674 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294692 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294702 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294742 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294750 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294798 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294806 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294850 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294858 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294909 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294927 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294937 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294969 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294985 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294995 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295040 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 69 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295058 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 69 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295068 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 69 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295109 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295127 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295137 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295178 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295196 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295206 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295247 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295265 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295275 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295316 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295334 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295344 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295385 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295403 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295413 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295454 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295472 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295482 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295519 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295537 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295547 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295582 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295600 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295610 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295645 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295663 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295673 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295708 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295726 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295736 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295771 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295789 | Piano 1 (+4.80) | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0493 | 0.0308 | 0.02809 | Piano Primo | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000321494 | ø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295799 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295829 | Piano 1 (+4.80) | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.0445 | 0.02735 | 0.02478 | Piano Primo | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.000227933 | ø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
