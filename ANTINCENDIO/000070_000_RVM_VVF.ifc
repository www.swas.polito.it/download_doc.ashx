Properties of the parts of a building model (IFC2X3), part 44 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6309863 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.33182 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.334722 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1583 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309903 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.20432 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.805333 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1582 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309943 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.20432 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.805333 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1581 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6309983 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.20432 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.805333 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1580 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310023 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.20432 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.805333 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1579 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310386 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 4.64192 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.4583 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1939 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310637 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.59067 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.902435 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1868 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310651 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.18932 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.801563 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 376 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310696 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.23173 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.812223 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1867 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310735 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.20432 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.805333 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1866 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310780 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.19932 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.804076 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1865 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310831 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.19932 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.804076 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1864 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310843 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.58275 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.397788 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 52 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6310874 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 1.30957 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.411413 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1862 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6311536 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 1.7711 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.556406 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1861 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.68611 | 3.6861 | Protezione antincendio a secco 35
6312025 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.519283 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.13051 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1577 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312037 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.22432 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.810359 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1578 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312064 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 2.53563 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.796593 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1576 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312103 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1575 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312142 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1574 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312181 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1573 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312220 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.85205 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.21016 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1572 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312259 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1571 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312452 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.14252 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.987251 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1569 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312503 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 34.0894 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 10.7095 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.65 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3336 | 0.0008 | impianto a umido | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7 | 3.7 | Protezione antincendio a secco 35
6312728 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 2.31108 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.726046 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1567 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312779 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1947 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312891 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1961 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312904 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1975 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312917 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1989 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312938 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2002 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312951 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2004 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312964 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.16812 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.995293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2006 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312977 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.85205 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.21016 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2008 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6312990 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 453 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6313460 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.12943 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.98314 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2017 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6313472 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1570 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6314016 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 2 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 2 | Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6314033 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 2 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 32 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 2 | Dati identità - Commenti: Stacco
6314045 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2360 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6314053 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.34408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.294566 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2353 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6314056 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 2 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 2
6314278 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.33786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262155 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 3 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 3 | Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6314291 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 3 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 7 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 3 | Dati identità - Commenti: Stacco
6314296 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 3 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 3 | Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6314307 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.689092 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0865939 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2363 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6314544 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.305 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332255 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 2 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 2
6314562 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 2 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 2 | Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6314690 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 4 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6315032 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 2 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 2 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6315039 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 2 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 2 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6315103 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 5 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 5 | Dati identità - Commenti: Stacco
6315124 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2357 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6315143 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2368 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6315160 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 3 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 22 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 3 | Dati identità - Commenti: Stacco
6315190 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 3 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 3 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6315334 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 3 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 3 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6315905 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.30948 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332705 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2371 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6316208 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2370 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6316634 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 7 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 7 | Dati identità - Commenti: Stacco
6316638 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 9 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6317194 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2359 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6318214 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 6 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 6
6318219 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 1 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 1 | Dati identità - Commenti: Stacco
6318225 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2301 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318227 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.34408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.294566 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2296 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6318229 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 12 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 12
6318233 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.305 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332255 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 12 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 12
6318237 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 6 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 6
6318244 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 6 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 6 | Dati identità - Commenti: Stacco
6318249 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 6 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 6 | Dati identità - Commenti: Stacco
6318255 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 17 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 17 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6318260 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2298 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318272 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2300 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6318331 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 13 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 13
6318336 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 11 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 11 | Dati identità - Commenti: Stacco
6318342 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2289 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318344 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.34408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.294566 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2284 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6318346 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 18 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 18
6318350 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.305 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332255 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 18 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 18
6318354 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 13 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 13
6318361 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 13 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 13 | Dati identità - Commenti: Stacco
6318366 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 13 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 13 | Dati identità - Commenti: Stacco
6318372 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 23 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 23 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6318377 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2286 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318389 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2288 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6318450 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 19 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 19
6318455 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 16 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 16 | Dati identità - Commenti: Stacco
6318461 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2271 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318463 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.34408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.294566 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2266 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6318465 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 24 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 24
6318469 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.305 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332255 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 24 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 24
6318473 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 19 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 19
6318480 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 19 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 19 | Dati identità - Commenti: Stacco
6318485 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 19 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 19 | Dati identità - Commenti: Stacco
6318491 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 29 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 29 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6318496 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2268 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318508 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2270 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6318569 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 25 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 25
6318574 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 22 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 22 | Dati identità - Commenti: Stacco
6318580 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2236 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318582 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.34408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.294566 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2229 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6318584 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 30 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 30
6318588 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.305 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.332255 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 30 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 34 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 30
6318592 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 25 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 25
6318599 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 25 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 25 | Dati identità - Commenti: Stacco
6318604 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 25 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 25 | Dati identità - Commenti: Stacco
6318610 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 39 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 39 | Dati identità - Commenti: Stacco; Meccanico - Flusso - Caduta pressione: 0 Pa; Fattore di frizione: 0; Flusso: 0 m3/s; Flusso aggiuntivo: 0 m3/s; Frizione: 0; Numero di Reynolds: 0; Stato flusso: Laminare; Unità apparecchio: 0; Velocità: 0
6318615 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2233 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6318627 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2235 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
