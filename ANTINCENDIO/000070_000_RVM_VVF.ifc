Properties of the parts of a building model (IFC2X3), part 14 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6282024 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282032 | Piano 2 (+8.61) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282686 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6282688 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6283035 | Piano 2 (+8.61) | 0.0191 | 0.0179477 | 0.0162257 | 0.0160352 | 0.0143972 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0358953 | 0.0324513 | 0.0320704 | 0.0287944 | 0.0259932 | 0.0229973 | 0.0191 | 0.0163 | 0.0128282 | 0.0115178 | 0.0163 | ø19xø16 | 0.00685606 | 0.00652006 | 0.0375001 | 0.00955 | 0.00815 | 0.00303859 | 0.00289859 | 0.0000298937 | ø19 mmxø16 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa
6283315 | Piano 2 (+8.61) | 0.01905 | 0.0162257 | 0.0179169 | 0.0143972 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0324513 | 0.0358338 | 0.0287944 | 0.0320119 | 0.0229973 | 0.0259398 | 0.0163 | 0.01905 | 0.0115178 | 0.0128048 | 0.0163 | ø19xø16 | 0.00652006 | 0.00685006 | 0.0374531 | 0.00815 | 0.009525 | 0.00289859 | 0.00303609 | 0.0000297998 | ø19 mmxø16 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17673 | Protezione antincendio a secco 35
6283362 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6283783 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6284016 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 36
6284018 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6287199 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288351 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288353 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288359 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288369 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6288371 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288375 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288383 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6288429 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288431 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288437 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288447 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6288449 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288453 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288461 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6288662 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288868 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288916 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288918 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6288924 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6288934 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6289000 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6289251 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6289253 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6289259 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6289269 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6289273 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6289302 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6289304 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6289310 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6289320 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6289324 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6291521 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6291523 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6291549 | Piano 2 (+8.61) | 0.1 | 0.0544 | 0.0686 | 0.05032 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.1088 | 0.1372 | 0.10064 | 0.12786 | 0.0889 | 0.1144 | 0.08 | 0.1 | 0.040256 | 0.051144 | 0.08 | ø100xø80 | 0.0139 | 0.0168 | 0.1113 | 0.04 | 0.05 | 0.00587 | 0.00673 | 0.00120775 | ø100 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6291710 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6291748 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292023 | Piano 2 (+8.61) | 0.0163 | 0.0162257 | 0.0152 | 0.0143972 | 0.01332 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0324513 | 0.0304 | 0.0287944 | 0.02664 | 0.0229973 | 0.0213 | 0.0163 | 0.015 | 0.0115178 | 0.010656 | 0.015 | ø16xø15 | 0.00652006 | 0.0063 | 0.0348681 | 0.00815 | 0.0075 | 0.00289859 | 0.00267 | 0.0000232743 | ø16 mmxø15 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.06337 | Protezione antincendio a secco 35
6292025 | Piano 2 (+8.61) | 0.1 | 0.0152 | 0.0686 | 0.01332 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0304 | 0.1372 | 0.02664 | 0.12786 | 0.0213 | 0.1144 | 0.015 | 0.1 | 0.010656 | 0.051144 | 0.015 | ø100xø15 | 0.0063 | 0.0168 | 0.1113 | 0.0075 | 0.05 | 0.00267 | 0.00673 | 0.000725437 | ø100 mmxø15 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292056 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292114 | Piano 2 (+8.61) | 0.0163 | 0.0162257 | 0.0152 | 0.0143972 | 0.01332 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0324513 | 0.0304 | 0.0287944 | 0.02664 | 0.0229973 | 0.0213 | 0.0163 | 0.015 | 0.0115178 | 0.010656 | 0.015 | ø16xø15 | 0.00652006 | 0.0063 | 0.0348681 | 0.00815 | 0.0075 | 0.00289859 | 0.00267 | 0.0000232743 | ø16 mmxø15 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.06337 | Protezione antincendio a secco 35
6292116 | Piano 2 (+8.61) | 0.1 | 0.0152 | 0.0686 | 0.01332 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0304 | 0.1372 | 0.02664 | 0.12786 | 0.0213 | 0.1144 | 0.015 | 0.1 | 0.010656 | 0.051144 | 0.015 | ø100xø15 | 0.0063 | 0.0168 | 0.1113 | 0.0075 | 0.05 | 0.00267 | 0.00673 | 0.000725437 | ø100 mmxø15 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292147 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292202 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292233 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292347 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292378 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292409 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292440 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292467 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6292498 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6293551 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6293578 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6293687 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6293718 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6293834 | Piano 2 (+8.61) | 0.1 | 0.0686 | 0.0544 | 0.06393 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1372 | 0.1088 | 0.12786 | 0.10064 | 0.1144 | 0.0889 | 0.1 | 0.08 | 0.051144 | 0.040256 | 0.08 | ø100xø80 | 0.0168 | 0.0139 | 0.1113 | 0.05 | 0.04 | 0.00673 | 0.00587 | 0.00120775 | ø100 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6293944 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6293975 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6294002 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6294033 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6294115 | Piano 2 (+8.61) | 0.1 | 0.02735 | 0.0686 | 0.02478 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.1372 | 0.04956 | 0.12786 | 0.0422 | 0.1144 | 0.032 | 0.1 | 0.019824 | 0.051144 | 0.032 | ø100xø32 | 0.0087 | 0.0168 | 0.1113 | 0.016 | 0.05 | 0.00368 | 0.00673 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6294146 | Piano 2 (+8.61) | 0.1 | 0.0308 | 0.0686 | 0.02809 | 0.06393 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0616 | 0.1372 | 0.05618 | 0.12786 | 0.0483 | 0.1144 | 0.04 | 0.1 | 0.022472 | 0.051144 | 0.04 | ø100xø40 | 0.0093 | 0.0168 | 0.1113 | 0.02 | 0.05 | 0.00394 | 0.00673 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6294658 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6294660 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294662 | Piano 1 (+4.80) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294668 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa
6294678 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0445 | Protezione antincendio a secco 35
6294680 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa
6294688 | Piano 1 (+4.80) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294696 | Piano 1 (+4.80) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0493 | Protezione antincendio a secco 35
6294700 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6294706 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0445 | Protezione antincendio a secco 35
6294708 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6294716 | Piano 1 (+4.80) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294718 | Piano 1 (+4.80) | 0.08 | 0.0308 | 0.0544 | 0.02809 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0616 | 0.1088 | 0.05618 | 0.10064 | 0.0483 | 0.0889 | 0.04 | 0.08 | 0.022472 | 0.040256 | 0.04 | ø80xø40 | 0.0093 | 0.0139 | 0.0937 | 0.02 | 0.04 | 0.00394 | 0.00587 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294726 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6294728 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294732 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6294744 | Piano 1 (+4.80) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0493 | Protezione antincendio a secco 35
6294748 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6294754 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0445 | Protezione antincendio a secco 35
6294756 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6294762 | Piano 1 (+4.80) | 0.08 | 0.02735 | 0.0544 | 0.02478 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0547 | 0.1088 | 0.04956 | 0.10064 | 0.0422 | 0.0889 | 0.032 | 0.08 | 0.019824 | 0.040256 | 0.032 | ø80xø32 | 0.0087 | 0.0139 | 0.0937 | 0.016 | 0.04 | 0.00368 | 0.00587 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294764 | Piano 1 (+4.80) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294766 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294774 | Piano 1 (+4.80) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294782 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6294784 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6294788 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6294800 | Piano 1 (+4.80) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0493 | Protezione antincendio a secco 35
6294804 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
6294810 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.0445 | Protezione antincendio a secco 35
6294812 | Piano 1 (+4.80) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.21632 | Protezione antincendio a secco 35
