Properties of the parts of a building model (IFC2X3), part 40 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6296445 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 958 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296448 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 959 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296455 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 966 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296457 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 974 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296459 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 971 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296463 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 956 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296466 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 957 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296471 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 970 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296476 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 969 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296492 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 950 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296495 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 939 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296506 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 939 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296512 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 942 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296514 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 937 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296517 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 938 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296524 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 945 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296526 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 953 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296528 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 950 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296532 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 935 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296535 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 936 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296540 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 949 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296545 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 948 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296561 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 929 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296564 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 918 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296575 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 918 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296581 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 921 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296583 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 916 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296586 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 917 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296593 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 924 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296595 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 932 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296597 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 929 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296601 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 914 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296604 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 915 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296609 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 928 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296614 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 927 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296630 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.62293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.284544 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 853 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296633 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.57786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.281004 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 842 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296644 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 842 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296650 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 845 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296652 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.595 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.361409 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 840 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296655 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 841 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296662 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 848 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296664 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 856 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296666 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 853 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296670 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.506895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636983 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3125 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296673 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 839 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296678 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 852 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296698 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 887 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296708 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 879 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296712 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 882 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296714 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 890 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296716 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 887 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296718 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 876 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296724 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 886 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296729 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 885 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296746 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 879 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296748 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 878 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296754 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 870 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296764 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 862 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296768 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 865 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296770 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 873 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296772 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 870 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296774 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 859 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296780 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 869 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296785 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 868 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296802 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 862 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296804 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 861 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296810 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1228 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296812 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1227 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296814 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1226 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296816 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1225 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296818 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 1.93987 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.487542 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1224 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296834 | Piano 1 (+4.80) | Piano Primo | 0.0191 | 0.015 | ø15 | 2.35066 | ø15 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.110772 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7925 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1475 | 0.00533333 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296836 | Piano 1 (+4.80) | Piano Primo | 0.0191 | 0.015 | ø15 | 0.144305 | ø15 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00680022 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8285 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1475 | 0.00533333 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0285 | 3.17281 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296841 | Piano 1 (+4.80) | Piano Primo | 0.0191 | 0.015 | ø15 | 2.36566 | ø15 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.111479 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7925 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1490 | 0.00533333 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296843 | Piano 1 (+4.80) | Piano Primo | 0.021 | 0.0163 | ø16 | 0.113365 | ø16 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00580518 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.86337 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1491 | 0.00490798 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.06337 | 3.17673 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296848 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.43887 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.270089 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 356 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296852 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 356 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296856 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.781117 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0613488 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 356 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296860 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.1425 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0143257 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3179 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296866 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.054292 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00545802 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3179 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6296868 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.076622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601788 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.89679 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3181 | 0.0032 | impianto a secco | 1530.45 | Livello: Piano 1 (+4.80) | 3.0968 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6296871 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.47941 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.349788 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 87 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297012 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.00647894 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000508855 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 897 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297023 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.52286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1170 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297029 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1170 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297035 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1173 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297037 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1168 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297040 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1169 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297047 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1176 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297051 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.791192 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994242 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1166 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297054 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1167 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297062 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.52286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1183 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297068 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1183 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297074 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1186 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297076 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1181 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297079 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1182 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297086 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.908 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1189 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297090 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.794954 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0998968 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1179 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297093 | Piano 1 (+4.80) | Piano Primo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.78 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1180 | 0.002 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297099 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3128 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297104 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 3.74002 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.17496 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 819 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297107 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 818 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297114 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.275899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1194 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297120 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1194 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297126 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1197 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297128 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.803523 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0807789 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1192 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297131 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1193 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297146 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.275899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1202 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297152 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1202 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297158 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1205 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297160 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.803523 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0807789 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1200 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297163 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1201 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297174 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 3.51286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.275899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1210 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297180 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.83706 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1210 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297186 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8968 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1213 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6297188 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.803523 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0807789 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1208 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297191 | Piano 1 (+4.80) | Piano Primo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.784 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1209 | 0.0025 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297202 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 0.659176 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.207086 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 815 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297204 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 0.043936 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0138029 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3149 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297249 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 0.911 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.286199 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1223 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6297257 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1222 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
