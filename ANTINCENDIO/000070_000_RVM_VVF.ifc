Properties of the parts of a building model (IFC2X3), part 42 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6306554 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1971 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306558 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1959 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306561 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1962 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306596 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1979 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306603 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1979 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306609 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1982 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306611 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1977 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306614 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1978 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306621 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1985 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306625 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1973 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306628 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1976 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306665 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1993 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306672 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1993 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306678 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1996 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306680 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1991 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306683 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1992 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306690 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1999 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306694 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1987 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306697 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1990 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306732 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1555 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306739 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1555 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306745 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1558 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306747 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1553 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306750 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1554 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306757 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1561 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306761 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1551 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306764 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1552 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306799 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1541 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306806 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1541 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306812 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1544 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306814 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1539 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306817 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1540 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306824 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1547 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306828 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1537 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306831 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1538 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306864 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1527 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306871 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1527 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306877 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1530 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306879 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1525 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306882 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1526 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306889 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1533 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306893 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1523 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306896 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1524 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306931 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1513 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306938 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1513 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306944 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1516 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306946 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1511 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306949 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1512 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306956 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1519 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6306960 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1509 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306963 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1510 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6306998 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.35786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.263726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1499 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307005 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.15026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0118014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1499 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307011 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0905198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00710941 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1502 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307013 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.415 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343313 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1497 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307016 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1498 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307023 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0793198 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00622976 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1505 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307027 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.466688 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0586458 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1495 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307030 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1496 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307540 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1846 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307546 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1846 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307552 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1849 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307554 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.479016 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0481559 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1844 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307557 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1845 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307585 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.40286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26726 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2011 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307591 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2011 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307597 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2014 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307599 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.479016 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0481559 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2009 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307602 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2010 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307690 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1822 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307696 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1822 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307702 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1825 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307704 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1820 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307707 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1821 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307714 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1828 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307718 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.470452 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0591187 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1818 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307721 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1819 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307757 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1809 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307763 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1809 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307769 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1812 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307771 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.36 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.337784 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1807 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307774 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1808 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307781 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1815 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307785 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.520452 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0654019 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1805 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307788 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1806 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307824 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1796 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307830 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1796 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307836 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1799 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307838 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1794 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307841 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1795 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307848 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1802 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307852 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.470452 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0591187 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1792 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307855 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1793 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307891 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1783 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307897 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1783 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307903 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1786 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307905 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1781 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307908 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1782 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307915 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1789 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307919 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.470452 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0591187 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1779 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307922 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1780 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307958 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1770 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307964 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1770 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307970 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1773 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307972 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 3.41 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.342811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1768 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307975 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6701 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1769 | 0.0025 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307982 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.17932 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0140837 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7941 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1776 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7941 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6307986 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.470452 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0591187 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1766 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6307989 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6661 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1767 | 0.002 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308025 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 3.36286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.264118 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1757 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6308031 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.25026 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0196554 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.72316 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1757 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.72316 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6308037 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.19052 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0149634 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7829 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1760 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.97342 | 3.7829 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
