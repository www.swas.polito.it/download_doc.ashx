Properties of the parts of a building model (IFC2X3), part 47 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6321537 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.58786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.20325 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 107 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 107
6321543 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2767 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321545 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 107 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 107
6321549 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.46941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.310316 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2757 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321553 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 131 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6321556 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2762 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321559 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2770 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321562 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 107 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 107 | Dati identità - Commenti: Stacco
6321567 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 107 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 107 | Dati identità - Commenti: Stacco
6321580 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.61448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262836 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2765 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321582 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2764 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321591 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 146 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 146 | Dati identità - Commenti: Stacco
6321595 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 150 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6321687 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.58786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.20325 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 125 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 125
6321693 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2691 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321695 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 125 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 125
6321699 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.46941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.310316 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2681 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321703 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 140 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6321706 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2686 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321709 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2694 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321712 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 125 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 125 | Dati identità - Commenti: Stacco
6321717 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 125 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 125 | Dati identità - Commenti: Stacco
6321730 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.61448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262836 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2689 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321732 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2688 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321741 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 153 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 153 | Dati identità - Commenti: Stacco
6321745 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 155 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6321804 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.58786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.20325 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 135 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 135
6321810 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2707 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321812 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 135 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 135
6321816 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.46941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.310316 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2697 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321820 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 148 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6321823 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2702 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321826 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2710 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321829 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 135 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 135 | Dati identità - Commenti: Stacco
6321834 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 135 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 135 | Dati identità - Commenti: Stacco
6321847 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.61448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262836 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2705 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321849 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2704 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321858 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 158 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 158 | Dati identità - Commenti: Stacco
6321862 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 160 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6321921 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.58786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.20325 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 145 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 145
6321927 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2675 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321929 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 145 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 145
6321933 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 2.46941 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.310316 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2665 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321937 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 154 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6321940 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2670 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321943 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2678 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6321946 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 145 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 145 | Dati identità - Commenti: Stacco
6321951 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 145 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 145 | Dati identità - Commenti: Stacco
6321964 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.61448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.262836 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2673 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321966 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2672 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6321975 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 163 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 163 | Dati identità - Commenti: Stacco
6321979 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 165 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6322052 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.34786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26294 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 152 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 152
6322058 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2723 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322060 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 152 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 152
6322064 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.697808 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0876891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2715 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322068 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 159 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6322071 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2718 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322074 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2726 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322077 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 152 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 152 | Dati identità - Commenti: Stacco
6322082 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 152 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 152 | Dati identità - Commenti: Stacco
6322095 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.31448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.333208 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2721 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322097 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2720 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322106 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 168 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 168 | Dati identità - Commenti: Stacco
6322110 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 170 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6322215 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.34786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26294 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 157 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 157
6322221 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2647 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322223 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 157 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 157
6322227 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.697808 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0876891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2639 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322231 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 164 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6322234 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2642 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322237 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2650 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322240 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 157 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 157 | Dati identità - Commenti: Stacco
6322245 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 157 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 157 | Dati identità - Commenti: Stacco
6322258 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.31448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.333208 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2645 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322260 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2644 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322269 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 173 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 173 | Dati identità - Commenti: Stacco
6322273 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 175 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6322330 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.34786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26294 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 162 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 162
6322336 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2622 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322338 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 162 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 162
6322342 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.697808 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0876891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2614 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322346 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 169 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6322349 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2617 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322352 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2625 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322355 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 162 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 162 | Dati identità - Commenti: Stacco
6322360 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 162 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 162 | Dati identità - Commenti: Stacco
6322373 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.31448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.333208 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2620 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322375 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2619 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322384 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 178 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 178 | Dati identità - Commenti: Stacco
6322388 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 180 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6322445 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.34786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26294 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 167 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 167
6322451 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2597 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322453 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 167 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 167
6322457 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.697808 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0876891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2589 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322461 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 174 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6322464 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2592 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322467 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2600 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322470 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 167 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 167 | Dati identità - Commenti: Stacco
6322475 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 167 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 167 | Dati identità - Commenti: Stacco
6322488 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.31448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.333208 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2595 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322490 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2594 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322499 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 183 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 183 | Dati identità - Commenti: Stacco
6322503 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 185 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Dati identità - Commenti: Stacco
6322560 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 3.34786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26294 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 172 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 14 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 172
6322566 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2572 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322568 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 172 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 19 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 172
6322572 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.697808 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0876891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2564 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322576 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 179 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Dati identità - Commenti: Stacco
6322579 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2567 | 0.0032 | impianto a umido | 3511.34 | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322582 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177688 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2575 | 0.0032 | impianto a umido | 3493.36 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4032 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6322585 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 172 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 15 | 0.0032 | impianto a umido | 3382.64 | Livello: Piano 3 (+12.85) | 3.17696 | 3.4619 | Protezione antincendio a secco 172 | Dati identità - Commenti: Stacco
6322590 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 172 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 172 | Dati identità - Commenti: Stacco
6322603 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.31448 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.333208 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2570 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322605 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00301771 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000379217 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2569 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6322614 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.131822 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0103533 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 188 | 16.4516 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6016 | Protezione antincendio a secco 188 | Dati identità - Commenti: Stacco
