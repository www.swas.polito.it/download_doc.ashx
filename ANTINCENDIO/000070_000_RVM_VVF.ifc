Properties of the parts of a building model (IFC2X3), part 12 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6279940 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6279948 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6279952 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6279958 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6279960 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280019 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280022 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280024 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280030 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280040 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280042 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280050 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280058 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280062 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280068 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280070 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280129 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280132 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280134 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280140 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280150 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280152 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280160 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280168 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280172 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280178 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280180 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280241 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280246 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280252 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280262 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280264 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280272 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280280 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280349 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280354 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280360 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280370 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280372 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280380 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280388 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280400 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 132 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 132 | Meccanico - Flusso - Caduta pressione: 0 Pa
6280463 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280466 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280468 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280474 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280484 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280486 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280494 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280502 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280506 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280512 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280514 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280577 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280580 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280582 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280588 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280598 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280600 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280608 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280616 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280620 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280626 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280628 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280689 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280692 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280694 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280700 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280710 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280712 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280720 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280728 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280732 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280738 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280740 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280841 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280844 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280846 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280852 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280862 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280864 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280872 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280880 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280884 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280890 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280892 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6280953 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280956 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280958 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280964 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280974 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6280976 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6280984 | Piano 2 (+8.61) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6280992 | Piano 2 (+8.61) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0493 | Protezione antincendio a secco 35
6280996 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281002 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
6281004 | Piano 2 (+8.61) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.21632 | Protezione antincendio a secco 35
6281063 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281066 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281068 | Piano 2 (+8.61) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6281074 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6281084 | Piano 2 (+8.61) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.0445 | Protezione antincendio a secco 35
