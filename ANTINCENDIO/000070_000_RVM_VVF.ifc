Properties of the parts of a building model (IFC2X3), part 58 of 58

# IfcFlowTerminal: VVF_tipo_VK520_upright (752)
Name (VVF_tipo_VK520_upright:VVF_tipo_VK520_upright:...) | In | Contrassegno | Nome sistema | Tipo di sistema | Tipologia impianto | Host | Livello | Offset (m) | Group
6408410 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.8 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408411 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 120 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.8 | Protezione antincendio a secco 120 | Dati identità - Commenti: Rampa 0-1
6408424 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.21 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408425 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.27 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408434 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.79562 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408435 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.87562 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408450 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.44 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408451 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.4 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408464 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 156 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.99267 | Protezione antincendio a secco 156 | Dati identità - Commenti: Rampa 0-1
6408465 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 161 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.83267 | Protezione antincendio a secco 161 | Dati identità - Commenti: Rampa 0-1
6408480 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 176 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.42 | Protezione antincendio a secco 176 | Dati identità - Commenti: Rampa 0-1
6408481 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.42 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6408653 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 114 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 114
6408658 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 114 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 114
6408680 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 114 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 114
6408685 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | Protezione antincendio a secco 114 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : PR_VVF_0200_SPR_Sezione su scala | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.98 | Protezione antincendio a secco 114
6408989 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6408994 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6409015 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6409020 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6409042 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 151 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 151
6409047 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 166 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 166
6409067 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6409072 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6409094 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35
6409099 | Piano 1 (+4.80) | Piano Primo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 1 (+4.80) | Livello: Piano 1 (+4.80) | 3.3 | Protezione antincendio a secco 35

# IfcSystem: Protezione antincendio a secco (205)
Altro - Categoria: Sistema di tubazioni; Famiglia: Sistema di tubazioni: Protezione antincendio a secco; Famiglia e tipo: Sistema di tubazioni: Protezione antincendio a secco; ID tipo: Sistema di tubazioni: Protezione antincendio a secco; Tipo: Sistema di tubazioni: Protezione antincendio a secco
Name | Nome sistema | Numero di elementi | Volume (m3)
Protezione antincendio a secco 36 | Protezione antincendio a secco 36 | 27 | 0.219926
Protezione antincendio a secco 35 | Protezione antincendio a secco 35 | 641 | 5.67664
Protezione antincendio a secco 38 | Protezione antincendio a secco 38 | 5 | 0.0121481
Protezione antincendio a secco 132 | Protezione antincendio a secco 132 | 0 | 0.00011436
Protezione antincendio a secco 69 | Protezione antincendio a secco 69 | 5 | 0.0121481
Protezione antincendio a secco 80 | Protezione antincendio a secco 80 | 2 | 0.00264119
Protezione antincendio a secco 2 | Protezione antincendio a secco 2 | 3 | 0.00476766
Protezione antincendio a secco 3 | Protezione antincendio a secco 3 | 4 | 0.00233741
Protezione antincendio a secco 5 | Protezione antincendio a secco 5 | 1 | 0.0002766
Protezione antincendio a secco 7 | Protezione antincendio a secco 7 | 1 | 0.000083658
Protezione antincendio a secco 1 | Protezione antincendio a secco 1 | 1 | 0.0000904297
Protezione antincendio a secco 6 | Protezione antincendio a secco 6 | 2 | 0.00196514
Protezione antincendio a secco 12 | Protezione antincendio a secco 12 | 0 | 0.00269107
Protezione antincendio a secco 17 | Protezione antincendio a secco 17 | 1 | 0.0002766
Protezione antincendio a secco 11 | Protezione antincendio a secco 11 | 1 | 0.0000904297
Protezione antincendio a secco 13 | Protezione antincendio a secco 13 | 2 | 0.00196514
Protezione antincendio a secco 18 | Protezione antincendio a secco 18 | 0 | 0.00269107
Protezione antincendio a secco 23 | Protezione antincendio a secco 23 | 1 | 0.0002766
Protezione antincendio a secco 16 | Protezione antincendio a secco 16 | 1 | 0.0000904297
Protezione antincendio a secco 19 | Protezione antincendio a secco 19 | 2 | 0.00196514
Protezione antincendio a secco 24 | Protezione antincendio a secco 24 | 0 | 0.00269107
Protezione antincendio a secco 29 | Protezione antincendio a secco 29 | 1 | 0.0002766
Protezione antincendio a secco 22 | Protezione antincendio a secco 22 | 1 | 0.0000904297
Protezione antincendio a secco 25 | Protezione antincendio a secco 25 | 2 | 0.00196514
Protezione antincendio a secco 30 | Protezione antincendio a secco 30 | 0 | 0.00269107
Protezione antincendio a secco 39 | Protezione antincendio a secco 39 | 1 | 0.0002766
Protezione antincendio a secco 28 | Protezione antincendio a secco 28 | 1 | 0.0000904297
Protezione antincendio a secco 31 | Protezione antincendio a secco 31 | 2 | 0.00196514
Protezione antincendio a secco 41 | Protezione antincendio a secco 41 | 0 | 0.00269107
Protezione antincendio a secco 46 | Protezione antincendio a secco 46 | 1 | 0.0002766
Protezione antincendio a secco 34 | Protezione antincendio a secco 34 | 1 | 0.0000904297
Protezione antincendio a secco 42 | Protezione antincendio a secco 42 | 2 | 0.00196514
Protezione antincendio a secco 47 | Protezione antincendio a secco 47 | 0 | 0.00269107
Protezione antincendio a secco 52 | Protezione antincendio a secco 52 | 1 | 0.0002766
Protezione antincendio a secco 45 | Protezione antincendio a secco 45 | 1 | 0.0000904297
Protezione antincendio a secco 48 | Protezione antincendio a secco 48 | 2 | 0.00282907
Protezione antincendio a secco 58 | Protezione antincendio a secco 58 | 1 | 0.00311243
Protezione antincendio a secco 51 | Protezione antincendio a secco 51 | 2 | 0.000371785
Protezione antincendio a secco 54 | Protezione antincendio a secco 54 | 2 | 0.00196562
Protezione antincendio a secco 65 | Protezione antincendio a secco 65 | 1 | 0.000083658
Protezione antincendio a secco 55 | Protezione antincendio a secco 55 | 2 | 0.000371785
Protezione antincendio a secco 56 | Protezione antincendio a secco 56 | 2 | 0.00196562
Protezione antincendio a secco 72 | Protezione antincendio a secco 72 | 1 | 0.000083658
Protezione antincendio a secco 60 | Protezione antincendio a secco 60 | 2 | 0.000371785
Protezione antincendio a secco 61 | Protezione antincendio a secco 61 | 2 | 0.00196562
Protezione antincendio a secco 78 | Protezione antincendio a secco 78 | 1 | 0.000083658
Protezione antincendio a secco 64 | Protezione antincendio a secco 64 | 2 | 0.000371785
Protezione antincendio a secco 66 | Protezione antincendio a secco 66 | 2 | 0.00196562
Protezione antincendio a secco 85 | Protezione antincendio a secco 85 | 1 | 0.000083658
Protezione antincendio a secco 71 | Protezione antincendio a secco 71 | 2 | 0.000371785
Protezione antincendio a secco 73 | Protezione antincendio a secco 73 | 2 | 0.00196562
Protezione antincendio a secco 91 | Protezione antincendio a secco 91 | 1 | 0.000083658
Protezione antincendio a secco 79 | Protezione antincendio a secco 79 | 2 | 0.0016122
Protezione antincendio a secco 97 | Protezione antincendio a secco 97 | 1 | 0.000083658
Protezione antincendio a secco 86 | Protezione antincendio a secco 86 | 2 | 0.0016122
Protezione antincendio a secco 103 | Protezione antincendio a secco 103 | 1 | 0.000083658
Protezione antincendio a secco 92 | Protezione antincendio a secco 92 | 2 | 0.0016122
Protezione antincendio a secco 109 | Protezione antincendio a secco 109 | 1 | 0.000083658
Protezione antincendio a secco 98 | Protezione antincendio a secco 98 | 2 | 0.0016122
Protezione antincendio a secco 115 | Protezione antincendio a secco 115 | 1 | 0.000083658
Protezione antincendio a secco 104 | Protezione antincendio a secco 104 | 2 | 0.0016122
Protezione antincendio a secco 121 | Protezione antincendio a secco 121 | 1 | 0.000083658
Protezione antincendio a secco 110 | Protezione antincendio a secco 110 | 2 | 0.0016122
Protezione antincendio a secco 127 | Protezione antincendio a secco 127 | 1 | 0.000083658
Protezione antincendio a secco 116 | Protezione antincendio a secco 116 | 2 | 0.0016122
Protezione antincendio a secco 134 | Protezione antincendio a secco 134 | 1 | 0.000083658
Protezione antincendio a secco 122 | Protezione antincendio a secco 122 | 2 | 0.0016122
Protezione antincendio a secco 141 | Protezione antincendio a secco 141 | 1 | 0.000083658
Protezione antincendio a secco 128 | Protezione antincendio a secco 128 | 2 | 0.00183309
Protezione antincendio a secco 147 | Protezione antincendio a secco 147 | 1 | 0.000083658
Protezione antincendio a secco 95 | Protezione antincendio a secco 95 | 2 | 0.00183309
Protezione antincendio a secco 139 | Protezione antincendio a secco 139 | 1 | 0.000083658
Protezione antincendio a secco 107 | Protezione antincendio a secco 107 | 2 | 0.00159747
Protezione antincendio a secco 146 | Protezione antincendio a secco 146 | 1 | 0.000083658
Protezione antincendio a secco 125 | Protezione antincendio a secco 125 | 2 | 0.00159747
Protezione antincendio a secco 153 | Protezione antincendio a secco 153 | 1 | 0.000083658
Protezione antincendio a secco 135 | Protezione antincendio a secco 135 | 2 | 0.00159747
Protezione antincendio a secco 158 | Protezione antincendio a secco 158 | 1 | 0.000083658
Protezione antincendio a secco 145 | Protezione antincendio a secco 145 | 2 | 0.00159747
Protezione antincendio a secco 163 | Protezione antincendio a secco 163 | 1 | 0.000083658
Protezione antincendio a secco 152 | Protezione antincendio a secco 152 | 2 | 0.00197053
Protezione antincendio a secco 168 | Protezione antincendio a secco 168 | 1 | 0.000083658
Protezione antincendio a secco 157 | Protezione antincendio a secco 157 | 2 | 0.00197053
Protezione antincendio a secco 173 | Protezione antincendio a secco 173 | 1 | 0.000083658
Protezione antincendio a secco 162 | Protezione antincendio a secco 162 | 2 | 0.00197053
Protezione antincendio a secco 178 | Protezione antincendio a secco 178 | 1 | 0.000083658
Protezione antincendio a secco 167 | Protezione antincendio a secco 167 | 2 | 0.00197053
Protezione antincendio a secco 183 | Protezione antincendio a secco 183 | 1 | 0.000083658
Protezione antincendio a secco 172 | Protezione antincendio a secco 172 | 2 | 0.00197053
Protezione antincendio a secco 188 | Protezione antincendio a secco 188 | 1 | 0.000083658
Protezione antincendio a secco 177 | Protezione antincendio a secco 177 | 2 | 0.00197053
Protezione antincendio a secco 193 | Protezione antincendio a secco 193 | 1 | 0.000083658
Protezione antincendio a secco 182 | Protezione antincendio a secco 182 | 2 | 0.00197053
Protezione antincendio a secco 198 | Protezione antincendio a secco 198 | 1 | 0.000083658
Protezione antincendio a secco 187 | Protezione antincendio a secco 187 | 2 | 0.00197053
Protezione antincendio a secco 203 | Protezione antincendio a secco 203 | 1 | 0.000083658
Protezione antincendio a secco 192 | Protezione antincendio a secco 192 | 2 | 0.00197053
Protezione antincendio a secco 208 | Protezione antincendio a secco 208 | 1 | 0.000083658
Protezione antincendio a secco 197 | Protezione antincendio a secco 197 | 2 | 0.00197053
Protezione antincendio a secco 213 | Protezione antincendio a secco 213 | 1 | 0.000083658
Protezione antincendio a secco 202 | Protezione antincendio a secco 202 | 2 | 0.00197053
Protezione antincendio a secco 218 | Protezione antincendio a secco 218 | 1 | 0.000083658
Protezione antincendio a secco 206 | Protezione antincendio a secco 206 | 2 | 0.000371785
Protezione antincendio a secco 207 | Protezione antincendio a secco 207 | 2 | 0.00196562
Protezione antincendio a secco 224 | Protezione antincendio a secco 224 | 1 | 0.000083658
Protezione antincendio a secco 217 | Protezione antincendio a secco 217 | 1 | 0.0000904297
Protezione antincendio a secco 219 | Protezione antincendio a secco 219 | 2 | 0.00196514
Protezione antincendio a secco 225 | Protezione antincendio a secco 225 | 0 | 0.00269107
Protezione antincendio a secco 231 | Protezione antincendio a secco 231 | 1 | 0.0002766
Protezione antincendio a secco 223 | Protezione antincendio a secco 223 | 1 | 0.0000904297
Protezione antincendio a secco 227 | Protezione antincendio a secco 227 | 2 | 0.00196514
Protezione antincendio a secco 232 | Protezione antincendio a secco 232 | 0 | 0.00269107
Protezione antincendio a secco 237 | Protezione antincendio a secco 237 | 1 | 0.0002766
Protezione antincendio a secco 230 | Protezione antincendio a secco 230 | 1 | 0.0000904297
Protezione antincendio a secco 233 | Protezione antincendio a secco 233 | 2 | 0.00196514
Protezione antincendio a secco 238 | Protezione antincendio a secco 238 | 0 | 0.00269107
Protezione antincendio a secco 243 | Protezione antincendio a secco 243 | 1 | 0.0002766
Protezione antincendio a secco 236 | Protezione antincendio a secco 236 | 1 | 0.0000904297
Protezione antincendio a secco 239 | Protezione antincendio a secco 239 | 2 | 0.00196514
Protezione antincendio a secco 244 | Protezione antincendio a secco 244 | 0 | 0.00269107
Protezione antincendio a secco 249 | Protezione antincendio a secco 249 | 1 | 0.0002766
Protezione antincendio a secco 242 | Protezione antincendio a secco 242 | 1 | 0.0000904297
Protezione antincendio a secco 245 | Protezione antincendio a secco 245 | 2 | 0.00196514
Protezione antincendio a secco 250 | Protezione antincendio a secco 250 | 0 | 0.00269107
Protezione antincendio a secco 255 | Protezione antincendio a secco 255 | 1 | 0.0002766
Protezione antincendio a secco 248 | Protezione antincendio a secco 248 | 1 | 0.0000904297
Protezione antincendio a secco 251 | Protezione antincendio a secco 251 | 2 | 0.00196514
Protezione antincendio a secco 256 | Protezione antincendio a secco 256 | 0 | 0.00269107
Protezione antincendio a secco 261 | Protezione antincendio a secco 261 | 1 | 0.0002766
Protezione antincendio a secco 254 | Protezione antincendio a secco 254 | 1 | 0.0000904297
Protezione antincendio a secco 257 | Protezione antincendio a secco 257 | 2 | 0.00196514
Protezione antincendio a secco 262 | Protezione antincendio a secco 262 | 0 | 0.00269107
Protezione antincendio a secco 267 | Protezione antincendio a secco 267 | 1 | 0.0002766
Protezione antincendio a secco 260 | Protezione antincendio a secco 260 | 1 | 0.0000904297
Protezione antincendio a secco 263 | Protezione antincendio a secco 263 | 2 | 0.00196514
Protezione antincendio a secco 268 | Protezione antincendio a secco 268 | 0 | 0.00269107
Protezione antincendio a secco 273 | Protezione antincendio a secco 273 | 1 | 0.0002766
Protezione antincendio a secco 266 | Protezione antincendio a secco 266 | 1 | 0.0000904297
Protezione antincendio a secco 269 | Protezione antincendio a secco 269 | 2 | 0.00196514
Protezione antincendio a secco 274 | Protezione antincendio a secco 274 | 0 | 0.00269107
Protezione antincendio a secco 279 | Protezione antincendio a secco 279 | 1 | 0.0002766
Protezione antincendio a secco 272 | Protezione antincendio a secco 272 | 1 | 0.0000904297
Protezione antincendio a secco 275 | Protezione antincendio a secco 275 | 2 | 0.00196514
Protezione antincendio a secco 281 | Protezione antincendio a secco 281 | 1 | 0.0000904297
Protezione antincendio a secco 282 | Protezione antincendio a secco 282 | 2 | 0.00205349
Protezione antincendio a secco 288 | Protezione antincendio a secco 288 | 1 | 0.0002766
Protezione antincendio a secco 53 | Protezione antincendio a secco 53 | 1 | 0.0000904297
Protezione antincendio a secco 286 | Protezione antincendio a secco 286 | 2 | 0.00204368
Protezione antincendio a secco 293 | Protezione antincendio a secco 293 | 1 | 0.0002766
Protezione antincendio a secco 290 | Protezione antincendio a secco 290 | 1 | 0.0000904297
Protezione antincendio a secco 291 | Protezione antincendio a secco 291 | 2 | 0.00182643
Protezione antincendio a secco 300 | Protezione antincendio a secco 300 | 1 | 0.00311243
Protezione antincendio a secco 298 | Protezione antincendio a secco 298 | 1 | 0.0000904297
Protezione antincendio a secco 299 | Protezione antincendio a secco 299 | 2 | 0.00166079
Protezione antincendio a secco 305 | Protezione antincendio a secco 305 | 1 | 0.0002766
Protezione antincendio a secco 302 | Protezione antincendio a secco 302 | 1 | 0.0000904297
Protezione antincendio a secco 303 | Protezione antincendio a secco 303 | 2 | 0.00166079
Protezione antincendio a secco 310 | Protezione antincendio a secco 310 | 1 | 0.0002766
Protezione antincendio a secco 306 | Protezione antincendio a secco 306 | 1 | 0.0000904297
Protezione antincendio a secco 308 | Protezione antincendio a secco 308 | 2 | 0.00166079
Protezione antincendio a secco 315 | Protezione antincendio a secco 315 | 1 | 0.0002766
Protezione antincendio a secco 311 | Protezione antincendio a secco 311 | 1 | 0.0000904297
Protezione antincendio a secco 313 | Protezione antincendio a secco 313 | 2 | 0.00166079
Protezione antincendio a secco 320 | Protezione antincendio a secco 320 | 1 | 0.0002766
Protezione antincendio a secco 316 | Protezione antincendio a secco 316 | 1 | 0.0000904297
Protezione antincendio a secco 318 | Protezione antincendio a secco 318 | 2 | 0.00166079
Protezione antincendio a secco 325 | Protezione antincendio a secco 325 | 1 | 0.0002766
Protezione antincendio a secco 321 | Protezione antincendio a secco 321 | 1 | 0.0000904297
Protezione antincendio a secco 323 | Protezione antincendio a secco 323 | 2 | 0.00166079
Protezione antincendio a secco 330 | Protezione antincendio a secco 330 | 1 | 0.0002766
Protezione antincendio a secco 326 | Protezione antincendio a secco 326 | 1 | 0.0000904297
Protezione antincendio a secco 328 | Protezione antincendio a secco 328 | 2 | 0.00166079
Protezione antincendio a secco 335 | Protezione antincendio a secco 335 | 1 | 0.0002766
Protezione antincendio a secco 331 | Protezione antincendio a secco 331 | 1 | 0.0000904297
Protezione antincendio a secco 333 | Protezione antincendio a secco 333 | 2 | 0.00180806
Protezione antincendio a secco 344 | Protezione antincendio a secco 344 | 1 | 0.00311645
Protezione antincendio a secco 338 | Protezione antincendio a secco 338 | 1 | 0.0000904297
Protezione antincendio a secco 340 | Protezione antincendio a secco 340 | 2 | 0.00213203
Protezione antincendio a secco 346 | Protezione antincendio a secco 346 | 1 | 0.0002766
Protezione antincendio a secco 20 | Protezione antincendio a secco 20 | 1 | 0.0000904297
Protezione antincendio a secco 26 | Protezione antincendio a secco 26 | 2 | 0.0014939
Protezione antincendio a secco 8 | Protezione antincendio a secco 8 | 1 | 0.0000904297
Protezione antincendio a secco 14 | Protezione antincendio a secco 14 | 2 | 0.00147426
Protezione antincendio a secco 84 | Protezione antincendio a secco 84 | 1 | 0.00274248
Protezione antincendio a secco 43 | Protezione antincendio a secco 43 | 1 | 0.0000904297
Protezione antincendio a secco 59 | Protezione antincendio a secco 59 | 2 | 0.00147426
Protezione antincendio a secco 83 | Protezione antincendio a secco 83 | 1 | 0.00277309
Protezione antincendio a secco 70 | Protezione antincendio a secco 70 | 1 | 0.0000904297
Protezione antincendio a secco 76 | Protezione antincendio a secco 76 | 2 | 0.00147426
Protezione antincendio a secco 101 | Protezione antincendio a secco 101 | 1 | 0.00292352
Protezione antincendio a secco 96 | Protezione antincendio a secco 96 | 2 | 0.00154092
Protezione antincendio a secco 196 | Protezione antincendio a secco 196 | 1 | 0.000191606
Protezione antincendio a secco 201 | Protezione antincendio a secco 201 | 1 | 0.000117507
Protezione antincendio a secco 234 | Protezione antincendio a secco 234 | 1 | 0.000109434
Protezione antincendio a secco 264 | Protezione antincendio a secco 264 | 1
Protezione antincendio a secco 40 | Protezione antincendio a secco 40 | 2 | 0.00116956
Protezione antincendio a secco 90 | Protezione antincendio a secco 90 | 1 | 0.000609713
Protezione antincendio a secco 108 | Protezione antincendio a secco 108 | 1 | 0.000512234
Protezione antincendio a secco 114 | Protezione antincendio a secco 114 | 5 | 0.0482409
Protezione antincendio a secco 120 | Protezione antincendio a secco 120 | 1 | 0.000931203
Protezione antincendio a secco 156 | Protezione antincendio a secco 156 | 1 | 0.000191606
Protezione antincendio a secco 161 | Protezione antincendio a secco 161 | 1 | 0.000117507
Protezione antincendio a secco 176 | Protezione antincendio a secco 176 | 1 | 0.000109434
Protezione antincendio a secco 151 | Protezione antincendio a secco 151 | 1 | 0.000649908
Protezione antincendio a secco 166 | Protezione antincendio a secco 166 | 1 | 0.000519653
