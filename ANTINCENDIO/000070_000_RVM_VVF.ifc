Properties of the parts of a building model (IFC2X3), part 36 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6281523 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 707 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281530 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 714 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281532 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 722 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281534 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 719 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281538 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 704 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281541 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 705 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281546 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 718 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281551 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 717 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281607 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.54293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 741 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281610 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276292 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 730 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281622 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 730 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281628 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 733 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281630 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.495 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.351356 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 728 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281633 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 729 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281640 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 736 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281642 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 744 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281644 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 741 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281648 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.826895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.103911 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 726 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281651 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 727 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281656 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 740 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281661 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3695 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238209 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 739 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281741 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.62293 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.284544 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 803 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281744 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.57786 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.281004 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 792 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281756 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 792 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281762 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 795 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281764 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.595 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.361409 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 790 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281767 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 791 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281774 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 798 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281776 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 806 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281778 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 803 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281785 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 789 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281790 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00267469 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00026889 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 802 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281795 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.8095 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.282442 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 801 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281885 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 42 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281896 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 49 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281900 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281902 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 45 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281904 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 42 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281906 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 32 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281912 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 41 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281917 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 40 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281934 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 49 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281936 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 47 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281977 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.4962 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274591 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 781 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6281988 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 773 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281992 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 776 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281994 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 784 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281996 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 781 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6281998 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.783195 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0787354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 770 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282004 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.0253916 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00255264 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 780 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282009 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 2.3895 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.240219 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 779 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282026 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.49397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.274415 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 773 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282028 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0110069 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00138317 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 772 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282108 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 21 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282131 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 89 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282148 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 111 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282159 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 133 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282172 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 1.93987 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.487542 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 448 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282306 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.32645 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.730877 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 458 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282485 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 0.451081 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.141711 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 414 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6282574 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 0.466256 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.146478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 384 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6283008 | Piano 2 (+8.61) | Piano Secondo | 0.0191 | 0.015 | ø15 | 2.35066 | ø15 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.110772 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6025 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 473 | 0.00533333 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6283021 | Piano 2 (+8.61) | Piano Secondo | 0.021 | 0.0163 | ø16 | 0.115454 | ø16 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00591214 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6734 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 381 | 0.00490798 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17882 | 3.06337 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6283208 | Piano 2 (+8.61) | Piano Secondo | 0.0191 | 0.015 | ø15 | 2.35066 | ø15 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.110772 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6025 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 465 | 0.00533333 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6283210 | Piano 2 (+8.61) | Piano Secondo | 0.021 | 0.0163 | ø16 | 0.113365 | ø16 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00580518 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6734 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 466 | 0.00490798 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.06337 | 3.17673 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6283360 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.43887 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.270089 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 356 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6283364 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 356 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6283411 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.781117 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0613488 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 356 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6283538 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.1425 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0143257 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 357 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6283879 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.054292 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00545802 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 357 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6283959 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.076622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601788 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 362 | 0.0032 | impianto a secco | 1530.45 | Livello: Piano 2 (+8.61) | 3.0968 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6284009 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.47941 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.349788 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 87 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6287189 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.00647894 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000508855 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 752 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288349 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.52286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 406 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288355 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 406 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288361 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 409 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288363 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 404 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288366 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 405 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288373 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 412 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288377 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.791192 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0994242 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 402 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288380 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 403 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288427 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.52286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.276685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 391 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288433 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 391 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288439 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 394 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288441 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 3.49 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.350853 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 389 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288444 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 390 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288451 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0654218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00513822 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.718 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 397 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288455 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.794954 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0998968 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 387 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288458 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 388 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288655 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.09937 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.659536 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 384 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288848 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 3.74002 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.17496 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 400 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288861 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 399 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288914 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.275899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 418 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288920 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 418 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288926 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 421 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6288928 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.144662 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.014543 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 416 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288931 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 417 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6288981 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 0.813646 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.255614 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 384 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289180 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 0.61692 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.193811 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 414 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289249 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.275899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 437 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289255 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 437 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6289261 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 440 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6289263 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.144662 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.014543 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 435 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289266 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 436 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289300 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 3.51286 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.275899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 428 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289306 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.136362 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107098 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 428 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.03706 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6289312 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.0766218 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00601786 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.7068 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 431 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.17342 | 3.0968 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6289314 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.144662 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.014543 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 426 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289317 | Piano 2 (+8.61) | Piano Secondo | 0.037 | 0.032 | ø32 | 0.00724121 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000727966 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 427 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289384 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 424 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6289401 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 423 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6291382 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 0.911 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.286199 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 450 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6291573 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 451 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6292078 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 3.13597 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.985195 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 460 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6292169 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 3.74002 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.17496 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 468 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6292255 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 474 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6292289 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 479 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6292312 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 484 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6292517 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 455 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6293438 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 2.94407 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.924907 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 330 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6293741 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 0.760366 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.238876 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 523 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
