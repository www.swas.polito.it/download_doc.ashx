Properties of the parts of a building model (IFC2X3), part 54 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6409023 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.701333 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0550826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3324 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409027 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.13862 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0894267 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3327 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409032 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.79791 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.954518 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3319 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409043 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 151 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 151 | Dati identità - Commenti: Stacco
6409048 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 166 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 166 | Dati identità - Commenti: Stacco
6409052 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.788842 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0619555 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 166 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 166
6409059 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.0542 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0827963 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 151 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 151
6409068 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3310 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6409073 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3307 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6409077 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.809981 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636158 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3307 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409084 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.03549 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0813273 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3310 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409095 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3313 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6409100 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3316 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6409102 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.841613 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0661001 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3316 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409106 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.998719 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0784392 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3313 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409110 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 2.31887 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.582796 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3304 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409142 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.2649 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0665766 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3321 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.8 | 7.8 | Protezione antincendio a secco 35
6409144 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 1.96525 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.493921 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.39512 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3321 | 0.001 | impianto a secco | 0.184859 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.79169 | 7.43445 | Protezione antincendio a secco 35
6409262 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.625764 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.157272 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3304 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6409268 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.731228 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.183778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3318 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6410534 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 1.62177 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.509494 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3337 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6410904 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 0.616466 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.193668 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6361 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1568 | 0.0008 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6410978 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 3.92129 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.23191 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.78241 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1861 | 0.0008 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.78241 | 7.7037 | Protezione antincendio a secco 35
6411022 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 2.32686 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.731005 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.75 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1215 | 0.0008 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6411256 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.17317 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.29485 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2021 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6411299 | Piano 1 (+4.80) | Piano Primo | 0.108 | 0.1 | ø100 | 3.6174 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.13644 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8963 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3343 | 0.0008 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.8963 | 11.5137 | Protezione antincendio a secco 35
6411351 | Piano 2 (+8.61) | Piano Secondo | 0.108 | 0.1 | ø100 | 1.60659 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.504725 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.56 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3343 | 0.0008 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6411476 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.108 | 0.1 | ø100 | 2.18275 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.68573 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3336 | 0.0008 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6411483 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 12.4422 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 3.90884 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.81148 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3336 | 0.0008 | impianto a umido |  | Livello: Piano 1 (+4.80) | -0.98852 | 11.4537 | Protezione antincendio a secco 35
6413447 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 2.8437 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.893375 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 0.746102 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 1939 | 0.0008 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.5898 | 0.746102 | Protezione antincendio a secco 35
6413837 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 4.29192 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.34835 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.65 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3336 | 0.0008 | impianto a umido | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.7 | 3.7 | Protezione antincendio a secco 35
6413846 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.108 | 0.1 | ø100 | 2.84242 | ø100 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.892972 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 0.746102 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3336 | 0.0008 | impianto a umido |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 0.746102 | 3.58852 | Protezione antincendio a secco 35
6418635 | Piano 3 contr (+16.01) luci | 9407 | 0.044 | 0.04 | ø40 | 1.83741 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.230896 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3351 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6418695 | Piano 3 contr (+16.01) luci | 9408 | 0.085 | 0.08 | ø80 | 2.1969 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.552141 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2173 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6418778 | Piano 3 contr (+16.01) luci | 9409 | 0.085 | 0.08 | ø80 | 0.48088 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.120858 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2163 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6418792 | Piano 3 contr (+16.01) luci | 9410 | 0.044 | 0.04 | ø40 | 0.18016 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0226396 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3351 | 0.002 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6418838 | Piano 3 contr (+16.01) luci | 9411 | 0.044 | 0.04 | ø40 | 1.83741 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.230896 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2100 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6418935 | Piano 3 contr (+16.01) luci | 9413 | 0.085 | 0.08 | ø80 | 0.474068 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.119146 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2102 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6418960 | Piano 3 contr (+16.01) luci | 9414 | 0.044 | 0.04 | ø40 | 0.16016 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0201263 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2100 | 0.002 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6418998 | Piano 3 contr (+16.01) luci | 9415 | 0.085 | 0.08 | ø80 | 2.56396 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.644392 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2098 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6419109 | Piano 2 (+8.61) | 9416 | 0.085 | 0.08 | ø80 | 2.78027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.698758 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3359 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419121 | Piano 2 (+8.61) | 9417 | 0.085 | 0.08 | ø80 | 2.98027 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.749023 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 578 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419157 | Piano 2 (+8.61) | 9418 | 0.037 | 0.032 | ø32 | 0.11148 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112072 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 651 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419171 | Piano 2 (+8.61) | 9419 | 0.037 | 0.032 | ø32 | 0.905005 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.090981 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 651 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419189 | Piano 2 (+8.61) | 9420 | 0.085 | 0.08 | ø80 | 0.0436 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0109579 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3357 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419234 | Piano 2 (+8.61) | 9421 | 0.031 | 0.025 | ø25 | 2.52484 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.1983 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3361 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419287 | Piano 2 (+8.61) | 9422 | 0.031 | 0.025 | ø25 | 0.12588 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00988659 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3361 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419301 | Piano 2 (+8.61) | 9423 | 0.031 | 0.025 | ø25 | 0.480799 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0377618 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3361 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419311 | Piano 2 (+8.61) | 9424 | 0.031 | 0.025 | ø25 | 0.1238 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00972323 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3361 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419324 | Piano 2 (+8.61) | 9425 | 0.031 | 0.025 | ø25 | 0.1038 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00815243 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3363 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419339 | Piano 2 (+8.61) | 9427 | 0.031 | 0.025 | ø25 | 0.46484 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0365084 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3363 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419351 | Piano 2 (+8.61) | 9428 | 0.031 | 0.025 | ø25 | 0.10588 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0083158 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3363 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419360 | Piano 2 (+8.61) | 9429 | 0.031 | 0.025 | ø25 | 2.53766 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.199308 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3363 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419441 | Piano 2 (+8.61) | 9431 | 0.037 | 0.032 | ø32 | 0.15148 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0152284 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3367 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419456 | Piano 2 (+8.61) | 9433 | 0.037 | 0.032 | ø32 | 0.49124 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0493848 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3367 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419471 | Piano 2 (+8.61) | 9434 | 0.037 | 0.032 | ø32 | 0.151 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0151802 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3367 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419480 | Piano 2 (+8.61) | 9435 | 0.037 | 0.032 | ø32 | 1.4073 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.141478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3367 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419609 | Piano 2 (+8.61) | 9437 | 0.031 | 0.025 | ø25 | 2.5638 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.20136 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3370 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419677 | Piano 2 (+8.61) | 9438 | 0.031 | 0.025 | ø25 | 0.0838 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00658164 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3370 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419687 | Piano 2 (+8.61) | 9439 | 0.031 | 0.025 | ø25 | 0.420799 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0330495 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3370 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6419699 | Piano 2 (+8.61) | 9440 | 0.031 | 0.025 | ø25 | 0.08588 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.006745 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3370 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6420783 | Piano 2 (+8.61) | 9442 | 0.037 | 0.032 | ø32 | 1.34054 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.134766 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 537 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6420838 | Piano 2 (+8.61) | 9443 | 0.037 | 0.032 | ø32 | 0.09148 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00919657 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 537 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6420849 | Piano 2 (+8.61) | 9444 | 0.037 | 0.032 | ø32 | 0.54474 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0547632 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 537 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6420883 | Piano 2 (+8.61) | 9445 | 0.037 | 0.032 | ø32 | 0.091 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00914832 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 537 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6421179 | Piano 2 (+8.61) | 9448 | 0.037 | 0.032 | ø32 | 1.3203 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.132732 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 258 | 0.0025 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6421216 | Piano 2 (+8.61) | 9449 | 0.037 | 0.032 | ø32 | 0.071 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0071377 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 258 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6421229 | Piano 2 (+8.61) | 9450 | 0.037 | 0.032 | ø32 | 0.60924 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0612475 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 258 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6421273 | Piano 2 (+8.61) | 9451 | 0.037 | 0.032 | ø32 | 0.07148 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00718595 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.594 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 258 | 0.0025 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6421633 | Piano 2 (+8.61) | 9452 | 0.031 | 0.025 | ø25 | 2.38254 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.187124 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 249 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6421952 | Piano 3 contr (+16.01) luci | 9457 | 0.037 | 0.032 | ø32 | 2.23124 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.224309 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2278 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422028 | Piano 3 contr (+16.01) luci | 9459 | 0.037 | 0.032 | ø32 | 0.311 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0312651 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2278 | 0.0025 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422039 | Piano 3 contr (+16.01) luci | 9460 | 0.037 | 0.032 | ø32 | 1.28474 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.129156 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2278 | 0.0025 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422138 | Piano 3 contr (+16.01) luci | 9461 | 0.037 | 0.032 | ø32 | 0.31148 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0313134 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2278 | 0.0025 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422303 | Piano 3 contr (+16.01) luci | 9463 | 0.044 | 0.04 | ø40 | 2.35956 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.296511 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2749 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422471 | Piano 3 contr (+16.01) luci | 9464 | 0.044 | 0.04 | ø40 | 0.20016 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0251528 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2749 | 0.002 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422567 | Piano 3 contr (+16.01) luci | 9465 | 0.044 | 0.04 | ø40 | 0.98268 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.123487 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2749 | 0.002 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422580 | Piano 3 contr (+16.01) luci | 9466 | 0.044 | 0.04 | ø40 | 0.2014 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0253087 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2749 | 0.002 |  | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6422634 | Piano 2 (+8.61) | 9467 | 0.031 | 0.025 | ø25 | 0.1038 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00815243 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 249 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6422645 | Piano 2 (+8.61) | 9468 | 0.031 | 0.025 | ø25 | 0.7424 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.058308 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 249 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6422677 | Piano 2 (+8.61) | 9469 | 0.031 | 0.025 | ø25 | 0.10588 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0083158 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 249 | 0.0032 |  | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35

# IfcFlowTerminal: VVF_tipo_VK510 - pendent (194)
In: Piano 3 (+12.85)
Type - Material: VK510 Deflector, VK510 Support, VK510 Trigger, Left Element, Right Element, VK510 Spring, VK510 Screw, VK510 Seat, VK510 Pip Cap, VK510 Frame
Type - Altro - Categoria: Estintori; Nome famiglia: VVF_tipo_VK510 - pendent
Type - Dati identità - Modello: VK510; Nome del tipo: VVF_tipo_VK510 - pendent; Produttore: Viking
Type - Protezione antincendio - Classe di pressione: Standard; Copertura: Standard; Orifizio: Molto grande; Risposta: Standard; Dimensione orifizio: 0.0238125 m; Fattore K: 25.2; Rapporto di temperatura: 73.8889 kg/K/s3
Type - Testo - Sprinkler Identification Number: VK510
Pset_ManufacturerTypeInformation - Manufacturer: Viking
Pset_DistributionFlowElementCommon - Reference: VVF_tipo_VK510 - pendent
Altro - Famiglia: VVF_tipo_VK510 - pendent: VVF_tipo_VK510 - pendent; Famiglia e tipo: VVF_tipo_VK510 - pendent: VVF_tipo_VK510 - pendent; ID tipo: VVF_tipo_VK510 - pendent: VVF_tipo_VK510 - pendent; Tipo: VVF_tipo_VK510 - pendent: VVF_tipo_VK510 - pendent
Dati identità - Contrassegno: Piano Uffici
Dimensioni - Volume: 0.0000271744 m3
Fasi - Fase di creazione: Stato di Progetto
Meccanica - Tipo di sistema: Sistema di tubazioni: Protezione antincendio a secco; Classificazione sistema: Mandata di sistema idronico
Meccanico - Flusso - Flusso: 0 m3/s
Testo - Tipologia impianto: impianto a umido
Vincoli - Livello: Livello: Piano 3 (+12.85); Host: Livello : Piano 3 (+12.85); Offset: 3.05 m
Name (VVF_tipo_VK510 - pendent:VVF_tipo_VK510 - pendent:...) | Nome sistema = Group
6314845 | Protezione antincendio a secco 2
6315102 | Protezione antincendio a secco 5
6315123 | Protezione antincendio a secco 35
6315142 | Protezione antincendio a secco 35
6315159 | Protezione antincendio a secco 3
6315189 | Protezione antincendio a secco 3
6318243 | Protezione antincendio a secco 6
6318254 | Protezione antincendio a secco 17
6318259 | Protezione antincendio a secco 35
6318360 | Protezione antincendio a secco 13
6318371 | Protezione antincendio a secco 23
6318376 | Protezione antincendio a secco 35
6318479 | Protezione antincendio a secco 19
6318490 | Protezione antincendio a secco 29
6318495 | Protezione antincendio a secco 35
6318598 | Protezione antincendio a secco 25
6318609 | Protezione antincendio a secco 39
6318614 | Protezione antincendio a secco 35
6318717 | Protezione antincendio a secco 31
6318728 | Protezione antincendio a secco 46
6318733 | Protezione antincendio a secco 35
6318832 | Protezione antincendio a secco 42
6318843 | Protezione antincendio a secco 52
6318848 | Protezione antincendio a secco 35
6318959 | Protezione antincendio a secco 48
6318970 | Protezione antincendio a secco 58
6318975 | Protezione antincendio a secco 35
6319102 | Protezione antincendio a secco 35
6319105 | Protezione antincendio a secco 51
6319108 | Protezione antincendio a secco 54
6319223 | Protezione antincendio a secco 35
6319226 | Protezione antincendio a secco 55
6319229 | Protezione antincendio a secco 56
6319340 | Protezione antincendio a secco 35
6319343 | Protezione antincendio a secco 60
6319346 | Protezione antincendio a secco 61
6319459 | Protezione antincendio a secco 35
6319462 | Protezione antincendio a secco 64
6319465 | Protezione antincendio a secco 66
6319576 | Protezione antincendio a secco 35
6319579 | Protezione antincendio a secco 71
6319582 | Protezione antincendio a secco 73
6319697 | Protezione antincendio a secco 35
6319700 | Protezione antincendio a secco 35
6319703 | Protezione antincendio a secco 79
6319841 | Protezione antincendio a secco 35
6319844 | Protezione antincendio a secco 35
6319847 | Protezione antincendio a secco 86
6320339 | Protezione antincendio a secco 35
6320342 | Protezione antincendio a secco 35
6320345 | Protezione antincendio a secco 92
6320456 | Protezione antincendio a secco 35
6320459 | Protezione antincendio a secco 35
6320462 | Protezione antincendio a secco 98
6320575 | Protezione antincendio a secco 35
6320578 | Protezione antincendio a secco 35
6320581 | Protezione antincendio a secco 104
6320692 | Protezione antincendio a secco 35
6320695 | Protezione antincendio a secco 35
6320698 | Protezione antincendio a secco 110
6320811 | Protezione antincendio a secco 35
6320814 | Protezione antincendio a secco 35
6320817 | Protezione antincendio a secco 116
6320926 | Protezione antincendio a secco 35
6320929 | Protezione antincendio a secco 35
6320932 | Protezione antincendio a secco 122
6321045 | Protezione antincendio a secco 35
6321048 | Protezione antincendio a secco 35
6321051 | Protezione antincendio a secco 128
6321426 | Protezione antincendio a secco 35
6321429 | Protezione antincendio a secco 35
6321432 | Protezione antincendio a secco 95
6321555 | Protezione antincendio a secco 35
6321558 | Protezione antincendio a secco 35
6321561 | Protezione antincendio a secco 107
6321705 | Protezione antincendio a secco 35
6321708 | Protezione antincendio a secco 35
6321711 | Protezione antincendio a secco 125
6321822 | Protezione antincendio a secco 35
6321825 | Protezione antincendio a secco 35
6321828 | Protezione antincendio a secco 135
6321939 | Protezione antincendio a secco 35
6321942 | Protezione antincendio a secco 35
6321945 | Protezione antincendio a secco 145
6322070 | Protezione antincendio a secco 35
6322073 | Protezione antincendio a secco 35
6322076 | Protezione antincendio a secco 152
6322233 | Protezione antincendio a secco 35
6322236 | Protezione antincendio a secco 35
6322239 | Protezione antincendio a secco 157
6322348 | Protezione antincendio a secco 35
6322351 | Protezione antincendio a secco 35
6322354 | Protezione antincendio a secco 162
6322463 | Protezione antincendio a secco 35
6322466 | Protezione antincendio a secco 35
6322469 | Protezione antincendio a secco 167
6322578 | Protezione antincendio a secco 35
6322581 | Protezione antincendio a secco 35
6322584 | Protezione antincendio a secco 172
6322693 | Protezione antincendio a secco 35
6322696 | Protezione antincendio a secco 35
6322699 | Protezione antincendio a secco 177
6322808 | Protezione antincendio a secco 35
6322811 | Protezione antincendio a secco 35
6322814 | Protezione antincendio a secco 182
6322923 | Protezione antincendio a secco 35
6322926 | Protezione antincendio a secco 35
6322929 | Protezione antincendio a secco 187
6323038 | Protezione antincendio a secco 35
6323041 | Protezione antincendio a secco 35
6323044 | Protezione antincendio a secco 192
6323153 | Protezione antincendio a secco 35
6323156 | Protezione antincendio a secco 35
6323159 | Protezione antincendio a secco 197
6323268 | Protezione antincendio a secco 35
6323271 | Protezione antincendio a secco 35
6323274 | Protezione antincendio a secco 202
6323393 | Protezione antincendio a secco 35
6323396 | Protezione antincendio a secco 206
6323399 | Protezione antincendio a secco 207
6323511 | Protezione antincendio a secco 35
6323634 | Protezione antincendio a secco 35
6323716 | Protezione antincendio a secco 219
6323727 | Protezione antincendio a secco 231
6323732 | Protezione antincendio a secco 35
6323853 | Protezione antincendio a secco 227
6323864 | Protezione antincendio a secco 237
6323869 | Protezione antincendio a secco 35
6323968 | Protezione antincendio a secco 233
6323979 | Protezione antincendio a secco 243
6323984 | Protezione antincendio a secco 35
6324083 | Protezione antincendio a secco 239
6324094 | Protezione antincendio a secco 249
6324099 | Protezione antincendio a secco 35
6324198 | Protezione antincendio a secco 245
6324209 | Protezione antincendio a secco 255
6324214 | Protezione antincendio a secco 35
6324313 | Protezione antincendio a secco 251
6324324 | Protezione antincendio a secco 261
6324329 | Protezione antincendio a secco 35
6324428 | Protezione antincendio a secco 257
6324439 | Protezione antincendio a secco 267
6324444 | Protezione antincendio a secco 35
6324543 | Protezione antincendio a secco 263
6324554 | Protezione antincendio a secco 273
6324559 | Protezione antincendio a secco 35
6324658 | Protezione antincendio a secco 269
6324669 | Protezione antincendio a secco 279
6324674 | Protezione antincendio a secco 35
6324773 | Protezione antincendio a secco 275
6324784 | Protezione antincendio a secco 35
6324789 | Protezione antincendio a secco 35
6325558 | Protezione antincendio a secco 35
6325642 | Protezione antincendio a secco 35
6325697 | Protezione antincendio a secco 282
6325708 | Protezione antincendio a secco 288
6325966 | Protezione antincendio a secco 286
6325977 | Protezione antincendio a secco 293
6326101 | Protezione antincendio a secco 291
6326112 | Protezione antincendio a secco 300
6326117 | Protezione antincendio a secco 35
6326711 | Protezione antincendio a secco 35
6326769 | Protezione antincendio a secco 35
6326802 | Protezione antincendio a secco 35
6326874 | Protezione antincendio a secco 299
6326885 | Protezione antincendio a secco 305
6326966 | Protezione antincendio a secco 303
6326977 | Protezione antincendio a secco 310
6327053 | Protezione antincendio a secco 308
6327064 | Protezione antincendio a secco 315
6327127 | Protezione antincendio a secco 313
6327138 | Protezione antincendio a secco 320
6327203 | Protezione antincendio a secco 318
6327214 | Protezione antincendio a secco 325
6327277 | Protezione antincendio a secco 323
6327288 | Protezione antincendio a secco 330
6327376 | Protezione antincendio a secco 328
6327387 | Protezione antincendio a secco 335
6327567 | Protezione antincendio a secco 333
6327578 | Protezione antincendio a secco 344
6327583 | Protezione antincendio a secco 35
6327752 | Protezione antincendio a secco 340
6327763 | Protezione antincendio a secco 346
6330309 | Protezione antincendio a secco 26
6330320 | Protezione antincendio a secco 35
6333263 | Protezione antincendio a secco 14
6333274 | Protezione antincendio a secco 84
6333279 | Protezione antincendio a secco 35
6333431 | Protezione antincendio a secco 59
6333442 | Protezione antincendio a secco 83
6333503 | Protezione antincendio a secco 76
6333514 | Protezione antincendio a secco 101
6333580 | Protezione antincendio a secco 35
6333633 | Protezione antincendio a secco 35

# IfcFlowTerminal: VVF_tipo_VK520_upright (752)
Type - Material: VK520 Lock Nut, VK520 Deflector, VK520 Screw, VK520 Trigger, VK520 Support, VK520 Element, VK520 Element Bottom, VK520 Pip Cap 2, VK520 Pip Cap 1, VK520 Spring, VK520 Frame
Type - Altro - Categoria: Estintori; Nome famiglia: VVF_tipo_VK520_upright
Type - Dati identità - Modello: VK520; Nome del tipo: VVF_tipo_VK520_upright; Produttore: Viking
Type - Protezione antincendio - Classe di pressione: Standard; Copertura: Standard; Dimensione orifizio: 0.01905 m; Fattore K: 14; Orifizio: Molto grande; Rapporto di temperatura: 73.8889 kg/K/s3; Risposta: Standard
Type - Testo - Sprinkler Identification Number: VK520
Pset_ManufacturerTypeInformation - Manufacturer: Viking
Pset_DistributionFlowElementCommon - Reference: VVF_tipo_VK520_upright
Altro - Famiglia: VVF_tipo_VK520_upright: VVF_tipo_VK520_upright; Famiglia e tipo: VVF_tipo_VK520_upright: VVF_tipo_VK520_upright; ID tipo: VVF_tipo_VK520_upright: VVF_tipo_VK520_upright; Tipo: VVF_tipo_VK520_upright: VVF_tipo_VK520_upright
Dimensioni - Volume: 0.0000254218 m3
Fasi - Fase di creazione: Stato di Progetto
Meccanica - Classificazione sistema: Protezione antincendio a secco
Meccanico - Flusso - Flusso: 0 m3/s
Name (VVF_tipo_VK520_upright:VVF_tipo_VK520_upright:...) | In | Contrassegno | Nome sistema | Tipo di sistema | Tipologia impianto | Host | Livello | Offset (m) | Group
6227336 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3
6267458 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6268086 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6268147 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6268169 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6268664 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 37 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3
6268777 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6268778 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6271730 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6271733 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6271734 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6271735 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273635 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273636 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273637 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273638 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273726 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273727 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273728 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6273729 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 36 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 36
6276673 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6276677 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6276678 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6278003 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6278006 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6278007 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6278008 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6278796 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 38 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 38
6278799 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 38 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 38
6278802 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 38 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 38
6278803 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 38 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 38
6278804 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 38 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 38
6279012 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279015 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279018 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279019 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279020 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279122 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
6279125 | Piano 2 (+8.61) | Piano Secondo | Protezione antincendio a secco 35 | Sistema di tubazioni: Protezione antincendio a secco | impianto a secco | Livello : Piano 2 (+8.61) | Livello: Piano 2 (+8.61) | 3.3 | Protezione antincendio a secco 35
