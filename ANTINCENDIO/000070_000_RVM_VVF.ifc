Properties of the parts of a building model (IFC2X3), part 2 of 58

# IfcFlowFitting: Standard (236)
Name (M_Croce - Filettata - MI - Classe 150:Standard:...) | In | Angolo 3 (deg) | Angolo 4 (deg) | Angolo 5 (deg) | Lunghezza 1 (m) = Da centro a estremità (m) | Lunghezza 2 (m) | Lunghezza 4 (m) | Lunghezza 5 (m) | Lunghezza 6 (m) | Lunghezza 7 (m) | Lunghezza 8 (m) | Raggio esterno banda (m) | Raggio esterno raccordo (m) | Contrassegno | Angolo 1 (deg) | Angolo 2 (deg) | Diametro esterno banda (m) | Diametro esterno raccordo (m) | Diametro interno raccordo (m) | Diametro nominale (m) = Dimensione massima (m) = Dimensione minima (m) | Dimensione contrassegno (m) | Dimensioni | Larghezza banda (m) | Raggio nominale (m) | Spessore metallo (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema = Group | Tipologia impianto | Livello | Host | Offset (m)
6281560 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281670 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6281926 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6282018 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Secondo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291673 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291862 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291878 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291896 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291912 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291928 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6291946 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6293507 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6293601 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6293617 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6293633 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6293649 | Piano 2 (+8.61) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Secondo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3
6294714 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294760 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294816 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294868 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6294947 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295005 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295078 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 69 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295147 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295216 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295285 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295354 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295423 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6295492 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296278 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296347 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296416 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296485 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296554 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296623 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296738 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6296794 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Primo | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297259 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297265 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297267 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297269 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297271 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297273 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297275 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297373 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297379 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297381 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297383 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6297385 | Piano 1 (+4.80) | 90 | 90 | 90 | 0.0963 | 0.0795 | 0.1926 | 0.1926 | 0.1926 | 0.0963 | 0.0963 | 0.0686 | 0.06393 | Piano Primo | 90 | 90 | 0.1372 | 0.12786 | 0.1144 | 0.1 | 0.051144 | ø100xø100xø100xø100 | 0.0168 | 0.05 | 0.00673 | 0.00368278 | ø100 mmxø100 mmxø100 mmxø100 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3
6302215 | PR_VVF_0200_SPR_Sezione su scala | 90 | 90 | 90 | 0.0782 | 0.0643 | 0.1564 | 0.1564 | 0.1564 | 0.0782 | 0.0782 | 0.0544 | 0.05032 | Piano Terra | 90 | 90 | 0.1088 | 0.10064 | 0.0889 | 0.08 | 0.040256 | ø80xø80xø80xø80 | 0.0139 | 0.04 | 0.00587 | 0.00188325 | ø80 mmxø80 mmxø80 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861
6315590 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6315695 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco,Mandata di sistema idronico,Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6316777 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 5 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6317047 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318262 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 17 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318266 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318379 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 23 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318383 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318498 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 29 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318502 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318617 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 39 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318621 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318736 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 46 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318740 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318851 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 52 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318855 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318978 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 58 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6318982 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319119 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 51 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319125 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319240 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 55 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319246 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319357 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 60 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319363 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319476 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 64 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319482 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319593 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 71 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319599 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319714 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319720 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319858 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6319864 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320356 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320362 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320473 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320479 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320592 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320598 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320709 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320715 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320828 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320834 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320943 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6320949 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321062 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321068 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321443 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321449 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321572 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321578 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321722 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321728 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321839 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321845 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321956 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6321962 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322087 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322093 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322250 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322256 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322365 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322371 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322480 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322486 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322595 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322601 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322710 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322716 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322825 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322831 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322940 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6322946 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323055 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323061 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323170 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323176 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323285 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323291 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323410 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 206 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323416 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323735 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 231 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323739 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323872 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 237 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323876 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323987 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0445 | 0.0358 | 0.089 | 0.089 | 0.089 | 0.0445 | 0.0445 | 0.02735 | 0.02478 | Piano Uffici | 90 | 90 | 0.0547 | 0.04956 | 0.0422 | 0.032 | 0.019824 | ø32xø32xø32xø32 | 0.0087 | 0.016 | 0.00368 | 0.00027686 | ø32 mmxø32 mmxø32 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 243 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
6323991 | Piano 3 (+12.85) | 90 | 90 | 90 | 0.0493 | 0.04 | 0.0986 | 0.0986 | 0.0986 | 0.0493 | 0.0493 | 0.0308 | 0.02809 | Piano Uffici | 90 | 90 | 0.0616 | 0.05618 | 0.0483 | 0.04 | 0.022472 | ø40xø40xø40xø40 | 0.0093 | 0.02 | 0.00394 | 0.000389257 | ø40 mmxø40 mmxø40 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5
