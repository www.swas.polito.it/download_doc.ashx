Properties of the parts of a building model (IFC2X3), part 51 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6329851 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.11962 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.532718 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2147 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329890 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.226846 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0570125 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2189 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329903 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.92663 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.735543 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2205 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329916 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.134391 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0337761 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2215 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6329987 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.08777 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.776041 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2241 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6330000 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.21757 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.808665 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2250 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6330186 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.0332565 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00835828 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2275 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6330198 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.15742 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.793547 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2231 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6330295 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.3763 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.186635 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 26 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 26
6330299 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 20 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 20 | Dati identità - Commenti: Stacco
6330305 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 26 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 26
6330310 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 26 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 26 | Dati identità - Commenti: Stacco
6330315 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 26 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 26 | Dati identità - Commenti: Stacco
6330321 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2280 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6330329 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.55217 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.357103 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2278 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6330409 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.952505 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.239391 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2276 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331261 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2307 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6331267 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.84434 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.714862 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2329 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331285 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.91471 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.732546 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2345 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331298 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.132141 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0332105 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2320 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331308 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2332 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6331317 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.99925 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.753793 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2355 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331330 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.0617765 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0155261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2336 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331343 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.0372371 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0093587 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2365 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331356 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.03331 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.762354 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2259 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331373 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2435 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331484 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.69126 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.425059 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2374 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331521 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.93846 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.487188 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2409 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331537 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.48874 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.374162 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2377 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331714 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.697808 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0876891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2423 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331752 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2428 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6331795 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2430 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6331825 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2393 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6331910 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2455 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6331933 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2457 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332094 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2487 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332216 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2512 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332337 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2537 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332470 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2562 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332586 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2587 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332709 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2612 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332807 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.0444 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.765142 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2713 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332931 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.47586 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.370923 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2667 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332953 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.58717 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.398899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2773 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6332979 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.72769 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.685544 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2683 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333011 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.2285 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.308755 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2664 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333131 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 1.24154 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.312033 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2637 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333170 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.3364 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.838529 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2740 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333193 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 2.93162 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.736796 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2759 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333209 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.32532 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.835745 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2743 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333236 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.183493 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 14 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 14
6333241 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 8 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 8 | Dati identità - Commenti: Stacco
6333247 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2754 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6333249 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.5234 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0657724 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2749 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333251 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 84 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 84
6333253 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 3.025 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.304106 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 84 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 84
6333257 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 14 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 14
6333264 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 14 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 14 | Dati identità - Commenti: Stacco
6333269 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 14 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 14 | Dati identità - Commenti: Stacco
6333275 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 84 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 84 | Dati identità - Commenti: Stacco
6333280 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2751 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6333292 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2753 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6333372 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 3.68785 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.926858 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2746 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333394 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.0318286 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0079994 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2747 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333417 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.183493 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 59 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 59
6333421 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 43 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 43 | Dati identità - Commenti: Stacco
6333427 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 59 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 59
6333432 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 59 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 59 | Dati identità - Commenti: Stacco
6333437 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 59 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 59 | Dati identità - Commenti: Stacco
6333443 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 83 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 83 | Dati identità - Commenti: Stacco
6333489 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 2.3363 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.183493 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 76 | 16.3375 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 36 | 0.0032 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 76
6333493 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.136622 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0107303 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 70 | 16.4468 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5968 | Protezione antincendio a secco 70 | Dati identità - Commenti: Stacco
6333499 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.00879511 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000884181 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 76 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 39 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 76
6333504 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.284939 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.022379 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 76 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 37 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4619 | 3.17696 | Protezione antincendio a secco 76 | Dati identità - Commenti: Stacco
6333509 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.195322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0153405 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 76 | 16.3881 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 31 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.5381 | Protezione antincendio a secco 76 | Dati identità - Commenti: Stacco
6333515 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.226239 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0177687 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 101 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 4 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.4032 | 3.17696 | Protezione antincendio a secco 101 | Dati identità - Commenti: Stacco
6333574 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2790 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6333576 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 4.06408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.510707 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2785 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333578 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 83 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 83
6333581 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2787 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6333589 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2789 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6333627 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.12082 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00948917 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.4626 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2780 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.73342 | 3.6126 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6333629 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 4.06408 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.510707 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2775 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333631 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.0075 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000942478 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 101 | 16.33 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 9 | 0.002 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 101
6333634 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.031 | 0.025 | ø25 | 0.215039 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0168891 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.027 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2777 | 0.0032 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.17696 | 3.392 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6333642 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.044 | 0.04 | ø40 | 0.00460189 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.000578291 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.3993 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2779 | 0.002 | impianto a umido |  | Livello: Piano 3 (+12.85) | 3.5493 | 3.5539 | Protezione antincendio a secco 35
6333675 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.293331 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0737221 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2699 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333687 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.085 | 0.08 | ø80 | 0.0328054 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00824491 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 16.31 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2783 | 0.001 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 35
6333751 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.14954 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0150334 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 83 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 83
6333790 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.68206 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.26963 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 83 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 83
6333833 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.114937 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0115548 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 83 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 83
6333890 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.16454 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0165414 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 101 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 101
6333902 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 2.76603 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.278071 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 101 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 101
6333916 | Piano 3 contr (+16.01) luci | Piano Uffici | 0.037 | 0.032 | ø32 | 0.203014 | ø32 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0204092 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 101 | 16.334 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 10 | 0.0025 | impianto a umido | 0 | Livello: Piano 3 (+12.85) | 3.5 | 3.5 | Protezione antincendio a secco 101
6377057 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 1.31923 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.331558 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.52237 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2861 | 0.001 | impianto a secco | 0.134322 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.56202 | 6.73764 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377063 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 3.10256 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.779759 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.69618 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 486 | 0.001 | impianto a secco | 0.154557 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.73571 | 5.20961 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377067 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.77122 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.445156 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.86364 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 478 | 0.001 | impianto a secco | 0.0918575 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.90347 | 4.06549 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377069 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.0318 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.25932 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2858 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377071 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.600673 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0471767 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 96 | 3.89876 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.91126 | 3.91127 | Protezione antincendio a secco 96 | Dati identità - Commenti: Rampa 0-1
6377077 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0740649 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00581704 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 96 | 3.94936 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.02342 | 3.94936 | Protezione antincendio a secco 96 | Dati identità - Commenti: Stacco
6377079 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.0888308 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00697675 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.93459 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2903 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.02342 | 3.93459 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377087 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.14922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0117197 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2908 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7242 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377089 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.14922 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0117197 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.7242 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2911 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.87342 | 3.7242 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377104 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.786961 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0618078 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2908 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377115 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.17981 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0926617 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.88384 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2903 | 0.0032 | impianto a secco | 0.000120747 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.89649 | 3.89634 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377135 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.375506 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0294921 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.29792 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2900 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.67342 | 4.29792 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377137 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.402997 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0316513 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 96 | 4.27042 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.67342 | 4.27042 | Protezione antincendio a secco 96 | Dati identità - Commenti: Stacco
6377165 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.321572 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0252562 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.76185 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2894 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.08342 | 4.76185 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377167 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.381545 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0299665 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.76188 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2897 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.14342 | 4.76188 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377195 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.257957 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0202599 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.41108 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2890 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.66904 | 5.41108 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377197 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.338126 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0265563 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.41091 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2892 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.74904 | 5.41091 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377205 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.858419 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.06742 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.36032 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2892 | 0.0032 | impianto a secco | 0.000365212 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.37314 | 5.37282 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377215 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.733387 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0576001 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.93835 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 499 | 0.0032 | impianto a secco | 0.000179718 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.95085 | 5.95099 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377221 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.32433 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0254728 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.98909 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 499 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.31342 | 5.98909 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377223 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.284306 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0223293 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.98912 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2888 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.27342 | 5.98912 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377227 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.888904 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0698144 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.93839 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2888 | 0.0032 | impianto a secco | 0.000134659 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.95089 | 5.95101 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
