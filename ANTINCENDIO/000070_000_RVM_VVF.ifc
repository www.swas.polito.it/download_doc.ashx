Properties of the parts of a building model (IFC2X3), part 31 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6377169 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.18632 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377193 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.66904 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377199 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.79194 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377219 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.31342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377225 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.31632 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377245 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 196 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.86609 | Protezione antincendio a secco 196 | Dati identità - Commenti: Rampa 0-1
6377251 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 201 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.74899 | Protezione antincendio a secco 201 | Dati identità - Commenti: Rampa 0-1
6377273 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 234 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.29342 | Protezione antincendio a secco 234 | Dati identità - Commenti: Rampa 0-1
6377279 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.33632 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6378438 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 96 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.91127 | Protezione antincendio a secco 96 | Dati identità - Commenti: Rampa 0-1
6378594 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.89634 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6380448 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.25979 | Protezione antincendio a secco 35 | Meccanico - Flusso - Caduta pressione: 0 Pa; Dati identità - Commenti: Rampa 0-1
6380600 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.25982 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381307 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72378 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381337 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 4.72375 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6382497 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37306 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6382796 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.37298 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6383074 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95088 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6383076 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 5.95089 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387176 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14692 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387179 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.14694 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387827 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.55158 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387832 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Terra | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 6.55162 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387893 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387895 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6388071 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | VE4555 | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 264 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.69342 | Protezione antincendio a secco 264 | Dati identità - Commenti: rampa 0-1
6388077 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | VE4556 | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.73632 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388087 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | VE4561 | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.79342 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388093 | PR_VVF_0200_SPR_Sezione su scala | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | VE4563 | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.83632 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388214 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | VE4617 | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43319 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388216 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | VE4618 | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43319 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388220 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | VE4619 | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43292 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388222 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | VE4620 | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 7.43294 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6400678 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6400740 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6402920 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6402960 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6403109 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403132 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403149 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6403156 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6403605 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403635 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6403660 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6403667 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6404151 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404153 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404179 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6404184 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6404370 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404372 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404456 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6404463 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 36
6404571 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404630 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 36 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 36
6404791 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404798 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404808 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404812 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404817 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404824 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404835 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404839 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404844 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404849 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404862 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404864 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404871 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404876 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404888 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404890 | Piano 2 (+8.61) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404898 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404905 | Piano 2 (+8.61) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Secondo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3.17342 | Protezione antincendio a secco 35
6404915 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6404919 | Piano 2 (+8.61) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Secondo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 2 (+8.61) | Livello : Piano 2 (+8.61) | 3 | Protezione antincendio a secco 35
6405239 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405246 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405256 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405260 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405265 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405272 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405283 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405287 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405292 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 40 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 40
6405297 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 40 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 40
6405310 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 40 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 40
6405312 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 40 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 40
6405319 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405324 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405336 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405338 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0225 | 0.05032 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.045 | 0.10064 | 0.0402 | 0.0889 | 0.0334 | 0.08 | 0.025 | 0.040256 | 0.01608 | 0.025 | ø80xø25 | 0.0139 | 0.0077 | 0.0937 | 0.04 | 0.0125 | 0.00587 | 0.0034 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405346 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405353 | Piano 1 (+4.80) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3.17342 | Protezione antincendio a secco 35
6405363 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6405367 | Piano 1 (+4.80) | 0.08 | 0.0225 | 0.0544 | 0.0201 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Primo | 0.045 | 0.1088 | 0.0402 | 0.10064 | 0.0334 | 0.0889 | 0.025 | 0.08 | 0.01608 | 0.040256 | 0.025 | ø80xø25 | 0.0077 | 0.0139 | 0.0937 | 0.0125 | 0.04 | 0.0034 | 0.00587 | 0.000439505 | ø80 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406130 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406431 | Piano 1 (+4.80) | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
6406490 | Piano 1 (+4.80) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Primo | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: Piano 1 (+4.80) | Livello : Piano 1 (+4.80) | 3 | Protezione antincendio a secco 35
