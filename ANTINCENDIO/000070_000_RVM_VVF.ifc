Properties of the parts of a building model (IFC2X3), part 22 of 58

# IfcFlowFitting: Standard (2277)
Name (M_Riduzione concentrica innesto - Filettata - MI - Classe 150:Standard:...) | In | Diametro nominale max 12 (m) = Dimensione massima (m) | Raggio esterno banda 1 (m) | Raggio esterno banda 2 (m) | Raggio esterno raccordo 1 (m) | Raggio esterno raccordo 2 (m) | Tipo | Visibilità 1 | Visibilità 2 | Contrassegno | Diametro esterno banda 1 (m) | Diametro esterno banda 2 (m) | Diametro esterno raccordo 1 (m) | Diametro esterno raccordo 2 (m) | Diametro interno raccordo 1 (m) | Diametro interno raccordo 2 (m) | Diametro nominale 1 (m) | Diametro nominale 2 (m) | Dimensione contrassegno 1 (m) | Dimensione contrassegno 2 (m) | Dimensione minima (m) | Dimensioni | Larghezza banda 1 (m) = Larghezza isolamento banda 1 (m) | Larghezza banda 2 (m) = Larghezza isolamento banda 2 (m) | Lunghezza (m) | Raggio nominale 1 (m) | Raggio nominale 2 (m) | Spessore metallo 1 (m) | Spessore metallo 2 (m) | Volume (m3) | Dimensione totale | Classificazione sistema | Nome sistema | Tipologia impianto | Livello | Host | Offset (m) | Group
6309552 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309603 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309659 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309699 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309750 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309790 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309830 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309870 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309910 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309950 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6309990 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310030 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310545 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0544 | 0.06393 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.1088 | 0.12786 | 0.10064 | 0.1144 | 0.0889 | 0.1 | 0.08 | 0.051144 | 0.040256 | 0.08 | ø100xø80 | 0.0168 | 0.0139 | 0.1113 | 0.05 | 0.04 | 0.00673 | 0.00587 | 0.00120775 | ø100 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310555 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310648 | PR_VVF_0200_SPR_Sezione su scala | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310658 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.02735 | 0.05032 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0547 | 0.10064 | 0.04956 | 0.0889 | 0.0422 | 0.08 | 0.032 | 0.040256 | 0.019824 | 0.032 | ø80xø32 | 0.0139 | 0.0087 | 0.0937 | 0.04 | 0.016 | 0.00587 | 0.00368 | 0.000476741 | ø80 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310715 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310754 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310799 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310850 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6310893 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312007 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0544 | 0.06393 | 0.05032 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.1088 | 0.12786 | 0.10064 | 0.1144 | 0.0889 | 0.1 | 0.08 | 0.051144 | 0.040256 | 0.08 | ø100xø80 | 0.0168 | 0.0139 | 0.1113 | 0.05 | 0.04 | 0.00673 | 0.00587 | 0.00120775 | ø100 mmxø80 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312044 | PR_VVF_0200_SPR_Sezione su scala | 0.08 | 0.0544 | 0.0308 | 0.05032 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1088 | 0.0616 | 0.10064 | 0.05618 | 0.0889 | 0.0483 | 0.08 | 0.04 | 0.040256 | 0.022472 | 0.04 | ø80xø40 | 0.0139 | 0.0093 | 0.0937 | 0.04 | 0.02 | 0.00587 | 0.00394 | 0.000506467 | ø80 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312083 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312122 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312161 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312200 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312239 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312278 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312430 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312471 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312798 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312898 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312911 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312924 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312945 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312958 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312971 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312984 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6312997 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.0308 | 0.06393 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0616 | 0.12786 | 0.05618 | 0.1144 | 0.0483 | 0.1 | 0.04 | 0.051144 | 0.022472 | 0.04 | ø100xø40 | 0.0168 | 0.0093 | 0.1113 | 0.05 | 0.02 | 0.00673 | 0.00394 | 0.000871321 | ø100 mmxø40 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6313479 | PR_VVF_0200_SPR_Sezione su scala | 0.1 | 0.0686 | 0.02735 | 0.06393 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Terra | 0.1372 | 0.0547 | 0.12786 | 0.04956 | 0.1144 | 0.0422 | 0.1 | 0.032 | 0.051144 | 0.019824 | 0.032 | ø100xø32 | 0.0168 | 0.0087 | 0.1113 | 0.05 | 0.016 | 0.00673 | 0.00368 | 0.000833506 | ø100 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a secco | Livello: PR_VVF_0200_SPR_Sezione su scala | Livello : PR_VVF_0200_SPR_Sezione su scala | 3.6861 | Protezione antincendio a secco 35
6314021 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Mandata di sistema idronico | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 2
6314041 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Meccanico - Flusso - Caduta pressione: 0 Pa
6314043 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6314281 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Mandata di sistema idronico | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 3
6314289 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 3
6314299 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 3
6314559 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 2
6314569 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 2
6314667 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 2
6315036 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Mandata di sistema idronico | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 2
6315070 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 2 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 2
6315105 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 5 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 5
6315331 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Mandata di sistema idronico | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 3
6315485 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 3
6315646 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 3
6315649 | Piano 3 (+12.85) | 0.032 | 0.0225 | 0.02735 | 0.0201 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0547 | 0.0402 | 0.04956 | 0.0334 | 0.0422 | 0.025 | 0.032 | 0.01608 | 0.019824 | 0.025 | ø32xø25 | 0.0077 | 0.0087 | 0.0523 | 0.0125 | 0.016 | 0.0034 | 0.00368 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 3 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4032 | Protezione antincendio a secco 3 | Meccanico - Flusso - Caduta pressione: 0 Pa
6316218 | Piano 3 (+12.85) | 0.04 | 0.02735 | 0.0308 | 0.02478 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0547 | 0.0616 | 0.04956 | 0.05618 | 0.0422 | 0.0483 | 0.032 | 0.04 | 0.019824 | 0.022472 | 0.032 | ø40xø32 | 0.0087 | 0.0093 | 0.0587 | 0.016 | 0.02 | 0.00368 | 0.00394 | 0.000137623 | ø40 mmxø32 mm | Mandata di sistema idronico | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 35
6316275 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6316277 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Mandata di sistema idronico | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6316632 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 7 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 7
6316636 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 7 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5493 | Protezione antincendio a secco 7 | Meccanico - Flusso - Caduta pressione: 0 Pa
6317012 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 5 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 5
6317125 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6317127 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6317229 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6318217 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 6 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 6
6318221 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 10 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6318223 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6318235 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 1 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 1
6318239 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 1 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 1 | Meccanico - Flusso - Caduta pressione: 0 Pa
6318241 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 12 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 12
6318246 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 6 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 6
6318252 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 6 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 6
6318257 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 17 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 17
6318264 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 17 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 17
6318268 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6318270 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6318274 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6318334 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 13 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 13
6318338 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 15 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6318340 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6318352 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 11 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 11
6318356 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 11 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 11 | Meccanico - Flusso - Caduta pressione: 0 Pa
6318358 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 18 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 18
6318363 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 13 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 13
6318369 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 13 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 13
6318374 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0208459 | 0.0201 | 0.018792 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0416917 | 0.0402 | 0.0375841 | 0.0334 | 0.0310356 | 0.025 | 0.0238125 | 0.01608 | 0.0150336 | 0.0238125 | ø25xø24 | 0.0077 | 0.00742156 | 0.0429 | 0.0125 | 0.0119063 | 0.0034 | 0.00327422 | 0.0000553883 | ø25 mmxø24 mm | Mandata di sistema idronico | Protezione antincendio a secco 23 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.17696 | Protezione antincendio a secco 23
6318381 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco,Mandata di sistema idronico | Protezione antincendio a secco 23 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.4555 | Protezione antincendio a secco 23
6318385 | Piano 3 (+12.85) | 0.025 | 0.0208459 | 0.0225 | 0.018792 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0416917 | 0.045 | 0.0375841 | 0.0402 | 0.0310356 | 0.0334 | 0.0238125 | 0.025 | 0.0150336 | 0.01608 | 0.0238125 | ø25xø24 | 0.00742156 | 0.0077 | 0.0429 | 0.0119063 | 0.0125 | 0.00327422 | 0.0034 | 0.0000553883 | ø25 mmxø24 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.13406 | Protezione antincendio a secco 35
6318387 | Piano 3 (+12.85) | 0.04 | 0.0225 | 0.0308 | 0.0201 | 0.02809 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.045 | 0.0616 | 0.0402 | 0.05618 | 0.0334 | 0.0483 | 0.025 | 0.04 | 0.01608 | 0.022472 | 0.025 | ø40xø25 | 0.0077 | 0.0093 | 0.0587 | 0.0125 | 0.02 | 0.0034 | 0.00394 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.392 | Protezione antincendio a secco 35
6318391 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.0225 | 0.02809 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.045 | 0.05618 | 0.0402 | 0.0483 | 0.0334 | 0.04 | 0.025 | 0.022472 | 0.01608 | 0.025 | ø40xø25 | 0.0093 | 0.0077 | 0.0587 | 0.02 | 0.0125 | 0.00394 | 0.0034 | 0.000116711 | ø40 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5539 | Protezione antincendio a secco 35
6318453 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 19 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 19
6318457 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 21 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445
6318459 | Piano 3 (+12.85) | 0.025 | 0.0225 | 0.0179169 | 0.0201 | 0.016006 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.045 | 0.0358338 | 0.0402 | 0.0320119 | 0.0334 | 0.0259398 | 0.025 | 0.01905 | 0.01608 | 0.0128048 | 0.01905 | ø25xø19 | 0.0077 | 0.00685006 | 0.0429 | 0.0125 | 0.009525 | 0.0034 | 0.00303609 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 35 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.73342 | Protezione antincendio a secco 35
6318471 | Piano 3 (+12.85) | 0.025 | 0.0179169 | 0.0225 | 0.016006 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | no | yes | Piano Uffici | 0.0358338 | 0.045 | 0.0320119 | 0.0402 | 0.0259398 | 0.0334 | 0.01905 | 0.025 | 0.0128048 | 0.01608 | 0.01905 | ø25xø19 | 0.00685006 | 0.0077 | 0.0429 | 0.009525 | 0.0125 | 0.00303609 | 0.0034 | 0.0000483036 | ø25 mmxø19 mm | Protezione antincendio a secco | Protezione antincendio a secco 16 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.77632 | Protezione antincendio a secco 16
6318475 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 16 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5445 | Protezione antincendio a secco 16 | Meccanico - Flusso - Caduta pressione: 0 Pa
6318477 | Piano 3 (+12.85) | 0.04 | 0.0308 | 0.02735 | 0.02809 | 0.02478 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0616 | 0.0547 | 0.05618 | 0.04956 | 0.0483 | 0.0422 | 0.04 | 0.032 | 0.022472 | 0.019824 | 0.032 | ø40xø32 | 0.0093 | 0.0087 | 0.0587 | 0.02 | 0.016 | 0.00394 | 0.00368 | 0.000137623 | ø40 mmxø32 mm | Protezione antincendio a secco | Protezione antincendio a secco 24 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 24
6318482 | Piano 3 (+12.85) | 0.032 | 0.02735 | 0.0225 | 0.02478 | 0.0201 | M_Riduzione concentrica innesto - Filettata - MI - Classe 150: Standard | yes | no | Piano Uffici | 0.0547 | 0.045 | 0.04956 | 0.0402 | 0.0422 | 0.0334 | 0.032 | 0.025 | 0.019824 | 0.01608 | 0.025 | ø32xø25 | 0.0087 | 0.0077 | 0.0523 | 0.016 | 0.0125 | 0.00368 | 0.0034 | 0.0000896851 | ø32 mmxø25 mm | Protezione antincendio a secco | Protezione antincendio a secco 19 | impianto a umido | Livello: Piano 3 (+12.85) | Livello : Piano 3 (+12.85) | 3.5 | Protezione antincendio a secco 19
