Properties of the parts of a building model (IFC2X3), part 52 of 58

# IfcFlowSegment: Tubazione:Acciaio - per impianto sprinkler (2538)
Name (Tubazione:Acciaio - per impianto sprinkler:...) | In | Contrassegno | Diametro esterno (m) | Diametro interno (m) = Diametro (m) | Dimensioni | Lunghezza (m) | Dimensione totale | Abaco/Tipo | Area (m2) | Descrizione segmento | Materiale | Nome sistema | Quota altimetrica fondo (m) | Ruvidità (m) | Segmento di tubazione | Sezione | Ruvidità relativa | Tipologia impianto | Inclinazione | Livello di riferimento | Offset (m) = Offset iniziale (m) | Offset finale (m) | Group
6377231 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 0.409198 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.102843 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.92261 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 498 | 0.001 | impianto a secco | 0.145961 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.96219 | 6.02129 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377247 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.302721 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0237756 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 196 | 6.56337 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.86609 | 6.56337 | Protezione antincendio a secco 196 | Dati identità - Commenti: Stacco
6377249 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.142773 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112133 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 201 | 6.56331 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.70609 | 6.56331 | Protezione antincendio a secco 201 | Dati identità - Commenti: Stacco
6377267 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 2.05158 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.515619 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.11723 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2862 | 0.001 | impianto a secco | 0.128608 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.15691 | 7.4186 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6377275 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 234 | 7.1581 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.29342 | 7.1581 | Protezione antincendio a secco 234 | Dati identità - Commenti: Stacco
6377277 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.108397 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.00851351 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.18502 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2877 | 0.0032 | impianto a secco |  | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.29342 | 7.18502 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6377782 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.16485 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.544085 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.65131 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2858 | 0.001 | impianto a secco | 0.0918575 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.69114 | 3.88917 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6379536 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.08966 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.525188 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.03453 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 478 | 0.001 | impianto a secco | 0.0858484 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.07438 | 4.25312 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6379673 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 2.61899 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.658225 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.22665 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2859 | 0.001 | impianto a secco | 0.0858484 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.2665 | 4.49051 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6380392 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.39742 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.109753 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 96 | 4.21922 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0032 | impianto a secco | 0.000429156 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.23232 | 4.23172 | Protezione antincendio a secco 96 | Dati identità - Commenti: Rampa 0-1
6380424 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 0.467088 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.036685 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.24732 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2900 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.25982 | 4.25982 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6380817 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 1.36844 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.343927 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.46327 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2859 | 0.001 | impianto a secco | 0.154557 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.5028 | 4.71183 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381181 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.733718 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0576261 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.71125 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2894 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.72375 | 4.72375 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381215 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 1.14412 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0898592 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 4.71128 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2897 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 4.72378 | 4.72378 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6381850 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 0.885906 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.222652 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.19417 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 486 | 0.001 | impianto a secco | 0.145961 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.23375 | 5.36171 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6382470 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.954321 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0749522 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.36048 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2890 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.37298 | 5.37298 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6382937 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 3.84481 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.966305 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.34471 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2860 | 0.001 | impianto a secco | 0.145961 | Livello: PR_VVF_0200_SPR_Sezione su scala | 5.38429 | 5.9396 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6385705 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 3.80065 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.955207 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 5.99558 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 498 | 0.001 | impianto a secco | 0.134322 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.03523 | 6.5412 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6385730 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 2.96446 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.74505 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.71914 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2861 | 0.001 | impianto a secco | 0.128608 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.75882 | 7.13696 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6386970 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.712792 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0559826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.13442 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2877 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.14692 | 7.14692 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387001 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.87984 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0691025 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.13444 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2880 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.14696 | 7.14694 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387639 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.889057 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0698263 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.53912 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2884 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.55162 | 6.55162 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387682 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 1.18902 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0933858 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 6.53906 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2882 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 6.55156 | 6.55158 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6387889 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.031 | 0.025 | ø25 | 1.04175 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0818188 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6736 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2911 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35
6387928 | PR_VVF_0200_SPR_Sezione su scala | Piano Terra | 0.085 | 0.08 | ø80 | 0.604374 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.151896 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 3.6461 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2906 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 3.6861 | 3.6861 | Protezione antincendio a secco 35 | Dati identità - Commenti: Rampa 0-1
6388083 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 1.14698 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0900834 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.42042 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3258 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.43292 | 7.43292 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388188 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 0.620723 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.156005 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.39319 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2922 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 2.63319 | 2.6332 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388208 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 1.79408 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.450901 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.39319 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2921 | 0.001 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.43319 | 7.43319 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388210 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.863197 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0677953 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.42069 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3256 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.43319 | 7.43319 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388212 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.950289 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0746355 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.42069 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3257 | 0.0032 | impianto a secco | 0 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.43319 | 7.43319 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6388218 | Piano 1 (+4.80) | Piano Terra | 0.031 | 0.025 | ø25 | 0.930562 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0730862 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.42044 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2930 | 0.0032 | impianto a secco | 0.000108423 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.43304 | 7.43294 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6391635 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.9818 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.00074 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3175 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6400673 | Piano 2 (+8.61) | Piano Secondo | 0.044 | 0.04 | ø40 | 0.506895 | ø40 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636983 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.59 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 788 | 0.002 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6401210 | Piano 1 (+4.80) | Piano Terra | 0.085 | 0.08 | ø80 | 2.39932 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.603014 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.39294 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2921 | 0.001 | impianto a secco | 0.0000935532 | Livello: PR_VVF_0200_SPR_Sezione su scala | 7.43316 | 7.43294 | Protezione antincendio a secco 35 | Dati identità - Commenti: rampa 0-1
6401851 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.9818 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 1.00074 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 366 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6402654 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.625764 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.157272 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 458 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6402665 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.731228 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.183778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 460 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6402696 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.083909 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0210886 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 487 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6402711 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.87907 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.974916 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 487 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6402748 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.0448728 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 467 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6402763 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.89541 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.979024 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 467 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6402806 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 462 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6402954 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 465 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6402956 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.729583 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0573013 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 465 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6403022 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.10785 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0870107 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 462 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6403062 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.0693874 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.017439 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 459 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6403147 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 472 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6403152 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 469 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6403154 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.701333 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0550826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 469 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6403158 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.13862 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0894267 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 472 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6403565 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.79791 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.954518 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 459 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6403658 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 479 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6403663 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 476 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6403669 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.788842 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0619555 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 476 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6404147 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.0542 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0827963 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 479 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6404177 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 485 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6404182 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 482 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6404186 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.809981 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636158 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 482 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6404366 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.03549 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0813273 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 485 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6404454 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 489 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6404459 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 492 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 36 | Dati identità - Commenti: Stacco
6404461 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.841613 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0661001 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 492 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6404465 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.998719 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0784392 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 489 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6404529 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.31887 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.582796 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 36 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 458 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 36
6404770 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.731228 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.183778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3057 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404776 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.083909 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0210886 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3074 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404780 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.87907 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.974916 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3074 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404782 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.0448728 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3059 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404786 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.89541 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.979024 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3059 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404789 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 462 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404794 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3071 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404796 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.729583 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0573013 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3071 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404800 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.10785 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0870107 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 462 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404804 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.0693874 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.017439 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3058 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404815 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 472 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404820 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3065 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404822 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.701333 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0550826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3065 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404826 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.13862 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0894267 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 472 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404831 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.79791 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.954518 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3058 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404842 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3063 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404847 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 476 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404851 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.788842 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0619555 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 476 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404859 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.0542 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0827963 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3063 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404869 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3079 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404874 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3076 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404878 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.809981 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636158 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3076 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404885 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 1.03549 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0813273 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3079 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404896 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3082 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404901 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.6481 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3083 | 0.0032 | impianto a secco |  | Livello: Piano 2 (+8.61) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6404903 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.841613 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0661001 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3083 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404907 | Piano 2 (+8.61) | Piano Secondo | 0.031 | 0.025 | ø25 | 0.998719 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0784392 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.5975 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3082 | 0.0032 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6404911 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 2.32825 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.585153 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3073 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6405131 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 0.616384 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.154914 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3073 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6405151 | Piano 2 (+8.61) | Piano Secondo | 0.085 | 0.08 | ø80 | 3.96654 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.996899 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 11.57 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 768 | 0.001 | impianto a secco | 0 | Livello: Piano 2 (+8.61) | 3 | 3 | Protezione antincendio a secco 35
6405218 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.625764 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.157272 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3161 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405224 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.083909 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0210886 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3162 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405228 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.87907 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.974916 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3162 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405230 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.0448728 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0112778 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3159 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405234 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.89541 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.979024 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3159 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405237 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3225 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6405242 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3228 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6405244 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.729583 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0573013 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3228 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405248 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.10785 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0870107 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3225 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405252 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 0.0693874 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.017439 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3160 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405263 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3234 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6405268 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3231 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6405270 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.701333 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0550826 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3231 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405274 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.13862 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0894267 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3234 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405279 | Piano 1 (+4.80) | Piano Primo | 0.085 | 0.08 | ø80 | 3.79791 | ø80 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.954518 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.76 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3160 | 0.001 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405290 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 40 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 40 | Dati identità - Commenti: Stacco
6405295 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 40 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 40 | Dati identità - Commenti: Stacco
6405299 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.788842 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0619555 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 40 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 5 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 40
6405307 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.0542 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0827963 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 40 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 2 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 40
6405317 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3167 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6405322 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3164 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
6405326 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.809981 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0636158 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3164 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405333 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 1.03549 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0813273 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.7875 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3167 | 0.0032 | impianto a secco | 0 | Livello: Piano 1 (+4.80) | 3 | 3 | Protezione antincendio a secco 35
6405344 | Piano 1 (+4.80) | Piano Primo | 0.031 | 0.025 | ø25 | 0.135322 | ø25 mm | Tipi di abaco delle tubazioni: Acciaio Nero/Zincato | 0.0106281 | serie leggera rif. Caleffi, tubazione in acciaio nero o zincato (p max 10bar filettati, 16bar lisci) | Acciaio , Lega | Protezione antincendio a secco 35 | 7.8381 | 0.00008 | Acciaio , Lega - Acciaio Nero/Zincato | 3170 | 0.0032 | impianto a secco |  | Livello: Piano 1 (+4.80) | 3.0381 | 3.17342 | Protezione antincendio a secco 35 | Dati identità - Commenti: Stacco
